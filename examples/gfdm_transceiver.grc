<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gfdm_transceiver</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>GFDM transceiver</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>gfdm_constellation</value></param>
<param><key>const_points</key><value>[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]</value></param>
<param><key>type</key><value>16qam</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gfdm_ic_iter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>IC Iteration Count</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gfdm_noise</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>Noise voltage</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>float(1.0/gfdm_var.nsubcarrier)</value></param>
</block>
<block>
<key>variable_preamble_generator</key>
<param><key>id</key><value>gfdm_pregen</value></param>
<param><key>filter_alpha</key><value>gfdm_var.filteralpha</value></param>
<param><key>nsubcarrier</key><value>gfdm_var.nsubcarrier</value></param>
<param><key>sync_fft_len</key><value>gfdm_var.syncfftlen</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>gfdm_var</value></param>
<param><key>field0</key><value>nsubcarrier</value></param>
<param><key>field1</key><value>ntimeslots</value></param>
<param><key>field2</key><value>fftlen</value></param>
<param><key>field3</key><value>syncfftlen</value></param>
<param><key>field4</key><value>cplen</value></param>
<param><key>field5</key><value>filteralpha</value></param>
<param><key>value4</key><value>10</value></param>
<param><key>value2</key><value>16*16</value></param>
<param><key>value5</key><value>0.3</value></param>
<param><key>value0</key><value>16</value></param>
<param><key>value1</key><value>16</value></param>
<param><key>value3</key><value>16*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mod_length_key</value></param>
<param><key>value</key><value>"frame_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>samp_rate_range</value></param>
<param><key>value</key><value>32e3</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Sample Rate Range</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>2e6</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>len(gfdm_constellation.points())</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>8192</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>100</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>mod_length_key</value></param>
<param><key>packet_len</key><value>gfdm_var.nsubcarrier*gfdm_var.ntimeslots</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>filter</key><value>mod_length_key</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>filter</key><value>mod_length_key</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>noise_voltage</key><value>gfdm_noise</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>gfdm_constellation.points()</value></param>
</block>
<block>
<key>gfdm_advanced_receiver_cc</key>
<param><key>id</key><value>gfdm_advanced_receiver_cc_0</value></param>
<param><key>constellation</key><value>gfdm_constellation</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_len</key><value>gfdm_var.fftlen</value></param>
<param><key>filter_alpha</key><value>gfdm_var.filteralpha</value></param>
<param><key>ic_iter</key><value>gfdm_ic_iter</value></param>
<param><key>len_tag_key</key><value>"frame_len"</value></param>
<param><key>nsubcarrier</key><value>gfdm_var.nsubcarrier</value></param>
<param><key>ntimeslots</key><value>gfdm_var.ntimeslots</value></param>
</block>
<block>
<key>gfdm_cyclic_prefixer_cc</key>
<param><key>id</key><value>gfdm_cyclic_prefixer_cc_0</value></param>
<param><key>cp_length</key><value>gfdm_var.cplen</value></param>
<param><key>len_tag_key</key><value>"frame_len"</value></param>
</block>
<block>
<key>gfdm_framer_cc</key>
<param><key>id</key><value>gfdm_framer_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>nsubcarrier</key><value>gfdm_var.nsubcarrier</value></param>
<param><key>ntimeslots</key><value>gfdm_var.ntimeslots</value></param>
<param><key>preamble_generator</key><value>gfdm_pregen</value></param>
<param><key>sync</key><value>True</value></param>
<param><key>sync_symbols</key><value>[ 0.27609610+0.41414415j, -0.25297725+0.10289432j,  0.15396781+0.24007586j, -0.01634210+0.28662329j, -0.30773501+0.09016927j, -0.32160103+0.3861782j ,  0.24410530+0.17509272j, -0.23171857-0.20296446j, -0.14857749+0.29715498j,  0.48258955+0.12185783j,  0.41298330+0.20510008j,  0.25915170+0.21641385j, -0.30773501-0.09016927j, -0.28180385-0.31329964j, -0.21482801-0.38143911j,  0.10696881+0.64303704j, -0.27609610-0.41414415j,  0.25297725-0.10289432j, -0.15396781-0.24007586j,  0.01634210-0.28662329j,  0.30773501-0.09016927j,  0.32160103-0.3861782j , -0.24410530-0.17509272j,  0.23171857+0.20296446j,  0.14857749-0.29715498j, -0.48258955-0.12185783j, -0.41298330-0.20510008j, -0.25915170-0.21641385j,  0.30773501+0.09016927j,  0.28180385+0.31329964j,  0.21482801+0.38143911j, -0.10696881-0.64303704j]</value></param>
</block>
<block>
<key>gfdm_modulator_cc</key>
<param><key>id</key><value>gfdm_modulator_cc_0</value></param>
<param><key>fft_len</key><value>gfdm_var.fftlen</value></param>
<param><key>filter_alpha</key><value>gfdm_var.filteralpha</value></param>
<param><key>len_tag_key</key><value>mod_length_key</value></param>
<param><key>nsubcarrier</key><value>gfdm_var.nsubcarrier</value></param>
<param><key>ntimeslots</key><value>gfdm_var.ntimeslots</value></param>
<param><key>sync_fft_len</key><value>gfdm_var.syncfftlen</value></param>
</block>
<block>
<key>gfdm_remove_prefix_cc</key>
<param><key>id</key><value>gfdm_remove_prefix_cc_0</value></param>
<param><key>cp_length</key><value>gfdm_var.cplen</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_len</key><value>gfdm_var.fftlen</value></param>
<param><key>gfdm_len_tag_key</key><value> "frame_len"</value></param>
<param><key>gfdm_sync_tag_key</key><value> "gfdm_sync"</value></param>
<param><key>sync_fft_len</key><value>gfdm_var.syncfftlen</value></param>
</block>
<block>
<key>gfdm_sync_cc</key>
<param><key>id</key><value>gfdm_sync_cc_0</value></param>
<param><key>cp_length</key><value>gfdm_var.cplen</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_len</key><value>gfdm_var.fftlen</value></param>
<param><key>gfdm_tag_key</key><value>"gfdm_sync"</value></param>
<param><key>preamble_generator</key><value>gfdm_pregen</value></param>
<param><key>sync_fft_len</key><value>gfdm_var.syncfftlen</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>size</key><value>2*gfdm_var.nsubcarrier*gfdm_var.ntimeslots</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1,2,3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Re{d} Symbole nach Demodulator</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Im{d} Symbole nach Demodulator</value></param>
<param><key>style2</key><value>0</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Re{d} Symbole vor dem Framer</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>Im{d} Symbole vor dem Framer</value></param>
<param><key>style4</key><value>0</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>100</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>integrierte Autokorrelationsmetrik</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Multiplikation mit Kreuzkorrelationsmetrik</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>symbols_in</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>symbols_tx</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>symbols_out</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>symbols_rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>symbols_in</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>symbols_in</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>symbols_rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>symbols_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>symbols_tx</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>gfdm_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_advanced_receiver_cc_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_cyclic_prefixer_cc_0</source_block_id><sink_block_id>blocks_tag_debug_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_cyclic_prefixer_cc_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_cyclic_prefixer_cc_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_framer_cc_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_framer_cc_0</source_block_id><sink_block_id>gfdm_modulator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_modulator_cc_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_modulator_cc_0</source_block_id><sink_block_id>gfdm_cyclic_prefixer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_remove_prefix_cc_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_sync_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_sync_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_sync_cc_0</source_block_id><sink_block_id>gfdm_remove_prefix_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_sync_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>gfdm_framer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>gfdm_modulator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>gfdm_advanced_receiver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
