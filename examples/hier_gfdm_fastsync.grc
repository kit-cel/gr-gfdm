options:
  parameters:
    author: Johannes Demel
    category: '[GFDM]'
    generate_options: hb
    id: hier_gfdm_fastsync
    output_language: python
    title: GFDM Fast Sync
  states: {}

blocks:
- name: preamble_len
  id: variable
  parameters:
    value: len(ref_preamble)
  states: {}
- name: a_frames
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: activate_cfo_compensation
  id: parameter
  parameters:
    label: Active CFO compensation
    type: intx
    value: '1'
  states: {}
- name: b_synced_stream
  id: pad_sink
  parameters:
    label: stream
    optional: 'True'
    type: complex
  states: {}
- name: c_correlation
  id: pad_sink
  parameters:
    label: corr
    optional: 'True'
    type: complex
  states: {}
- name: cp_len
  id: parameter
  parameters:
    label: CP length
    type: intx
    value: '32'
  states: {}
- name: d_auto_stream_0
  id: pad_sink
  parameters:
    label: autostream
    optional: 'True'
    type: complex
  states: {}
- name: e_correlation_0
  id: pad_sink
  parameters:
    label: autocorr
    optional: 'True'
    type: complex
  states: {}
- name: frame_len
  id: parameter
  parameters:
    label: Frame length
    type: intx
    value: '800'
  states: {}
- name: gfdm_extract_burst_cc_0
  id: gfdm_extract_burst_cc
  parameters:
    burst_len: frame_len
    burst_start_tag: output_tag_key
    minoutbuf: frame_len
    tag_backoff: cp_len
    use_cfo_compensation: activate_cfo_compensation
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: output_tag_key
  id: parameter
  parameters:
    label: Frame Tag Key
    type: str
    value: '"frame_start"'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: ref_preamble
  id: parameter
  parameters:
    label: Preamble
    value: np.ones(128)
  states: {}
- name: sc_high_thr
  id: parameter
  parameters:
    label: SC High Threshold
    type: eng_float
    value: '.7'
  states: {}
- name: sc_low_thr
  id: parameter
  parameters:
    label: SC Lower Threshold
    type: eng_float
    value: '.6'
  states: {}
- name: xcorr_comp_freq
  id: parameter
  parameters:
    label: Xcorr compensate freq.
    type: intx
    value: '1'
  states: {}
- name: xcorr_det_thr
  id: parameter
  parameters:
    label: XCorr Detection Threshold
    type: eng_float
    value: '100.'
  states: {}
- name: xfdm_sync_sc_delay_corr_0
  id: xfdm_sync_sc_delay_corr
  parameters:
    normalize: 'True'
    seq_len: preamble_len // 2
  states: {}
- name: xfdm_sync_sc_tagger_0
  id: xfdm_sync_sc_tagger
  parameters:
    seq_len: preamble_len // 2
    tag_key: output_tag_key
    thres_high: sc_high_thr
    thres_low: sc_low_thr
  states: {}
- name: xfdm_sync_xcorr_tagger_0
  id: xfdm_sync_xcorr_tagger
  parameters:
    sync_sequence: ref_preamble
    tag_key: output_tag_key
    threshold: xcorr_det_thr
    use_sc_rot: xcorr_comp_freq
  states: {}

connections:
- [gfdm_extract_burst_cc_0, '0', a_frames, '0']
- [pad_source_0, '0', xfdm_sync_sc_delay_corr_0, '0']
- [xfdm_sync_sc_delay_corr_0, '0', xfdm_sync_sc_tagger_0, '0']
- [xfdm_sync_sc_delay_corr_0, '1', xfdm_sync_sc_tagger_0, '1']
- [xfdm_sync_sc_tagger_0, '0', d_auto_stream_0, '0']
- [xfdm_sync_sc_tagger_0, '0', xfdm_sync_xcorr_tagger_0, '0']
- [xfdm_sync_sc_tagger_0, '1', e_correlation_0, '0']
- [xfdm_sync_sc_tagger_0, '1', xfdm_sync_xcorr_tagger_0, '1']
- [xfdm_sync_xcorr_tagger_0, '0', b_synced_stream, '0']
- [xfdm_sync_xcorr_tagger_0, '0', gfdm_extract_burst_cc_0, '0']
- [xfdm_sync_xcorr_tagger_0, '1', c_correlation, '0']

metadata:
  file_format: 1
