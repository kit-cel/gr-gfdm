<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hier_gfdm_fastsync</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>[GFDM]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>GFDM Fast Sync</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>value</key><value>len(ref_preamble)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>activate_cfo_compensation</value></param>
<param><key>label</key><value>Active CFO compensation</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>label</key><value>CP length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>label</key><value>Frame length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>800</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>frames</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>frames_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>stream</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>frames_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>corr</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>gfdm_extract_burst_cc</key>
<param><key>id</key><value>gfdm_extract_burst_cc_0</value></param>
<param><key>activate_cfo_compensation</key><value>activate_cfo_compensation</value></param>
<param><key>burst_start_tag</key><value>output_tag_key</value></param>
<param><key>tag_backoff</key><value>cp_len</value></param>
<param><key>burst_len</key><value>frame_len</value></param>
<param><key>minoutbuf</key><value>frame_len</value></param>
</block>
<block>
<key>hier_multicarrier_sync</key>
<param><key>id</key><value>hier_multicarrier_sync_0</value></param>
<param><key>output_tag_key</key><value>output_tag_key</value></param>
<param><key>ref_preamble</key><value>ref_preamble</value></param>
<param><key>sc_high_thr</key><value>sc_low_thr</value></param>
<param><key>sc_low_thr</key><value>sc_high_thr</value></param>
<param><key>xcorr_det_thr</key><value>xcorr_det_thr</value></param>
<param><key>xcorr_comp_freq</key><value>xcorr_comp_freq</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_numpy</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_tag_key</value></param>
<param><key>label</key><value>Frame Tag Key</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>frame_start</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ref_preamble</value></param>
<param><key>label</key><value>Preamble</value></param>
<param><key>value</key><value>np.ones(128)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sc_high_thr</value></param>
<param><key>label</key><value>SC Lower Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.7</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sc_low_thr</value></param>
<param><key>label</key><value>SC Lower Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>xcorr_comp_freq</value></param>
<param><key>label</key><value>Xcorr compensate freq.</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>xcorr_det_thr</value></param>
<param><key>label</key><value>XCorr Detection Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100.</value></param>
</block>
<connection><source_block_id>gfdm_extract_burst_cc_0</source_block_id><sink_block_id>frames</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_multicarrier_sync_0</source_block_id><sink_block_id>frames_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_multicarrier_sync_0</source_block_id><sink_block_id>gfdm_extract_burst_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_multicarrier_sync_0</source_block_id><sink_block_id>frames_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>hier_multicarrier_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
