<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gfdm_ota_test</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>send a simple random GFDM signal</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>GFDM over-the-air test</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>digital_multiply</value></param>
<param><key>value</key><value>1e-3</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e-4</value></param>
<param><key>step</key><value>1e-4</value></param>
<param><key>stop</key><value>.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_taps</value></param>
<param><key>value</key><value>filters.get_frequency_domain_filter('rrc', 1.0, timeslots, subcarriers, overlap)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2.484e9</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2.46e9</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>2.490e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>overlap</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>usrp_rate / 200.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeslots</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_rate</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>3</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>digital_multiply</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>[1+1j, -1+1j, -1-1j, 1-1j]</value></param>
</block>
<block>
<key>gfdm_simple_modulator_cc</key>
<param><key>id</key><value>gfdm_simple_modulator_cc_0</value></param>
<param><key>frequency_taps</key><value>f_taps</value></param>
<param><key>n_subcarriers</key><value>subcarriers</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>n_timeslots</key><value>timeslots</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_filters</value></param>
<param><key>import</key><value>from gfdm.pygfdm import filters</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>gfdm_simple_modulator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_modulator_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
