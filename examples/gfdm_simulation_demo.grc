options:
  parameters:
    author: Johannes Demel
    generate_options: qt_gui
    id: gfdm_simulation_demo
    output_language: python
    title: GFDM Simulation Demo
  states: {}

blocks:
- name: active_subcarriers
  id: variable
  parameters:
    value: '52'
  states: {}
- name: active_symbols
  id: variable_qtgui_label
  parameters:
    gui_hint: 'demod_tab@1: 0,1,1,1'
    label: Active Symbols
    type: int
    value: timeslots * active_subcarriers
  states: {}
- name: bits_per_frame
  id: variable_qtgui_label
  parameters:
    gui_hint: 'demod_tab@1: 0,2,1,1'
    label: Num bits
    type: int
    value: int(np.log2(len(gfdm_constellation.points() ) )) * active_symbols
  states: {}
- name: block_len
  id: variable
  parameters:
    value: timeslots * subcarriers
  states: {}
- name: chan_taps
  id: variable_qtgui_entry
  parameters:
    gui_hint: 'ctrl_tab@0: 2,0,1,1'
    label: Channel taps
    type: raw
    value: '[1.+1.j, .5]'
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: subcarriers // 2
  states: {}
- name: cs_len
  id: variable
  parameters:
    value: cp_len // 2
  states: {}
- name: data_rate
  id: variable_qtgui_label
  parameters:
    gui_hint: 'demod_tab@1: 0,3,1,1'
    label: Data Rate
    type: int
    value: int(1000. * bits_per_frame)
  states: {}
- name: estimator_type
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'ctrl_tab@0: 4,0,1,1'
    label: Estimator type
    label0: MF
    label1: ZF
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: f_taps
  id: variable
  parameters:
    value: filters.get_frequency_domain_filter('rrc', .2, timeslots, subcarriers, overlap)
  states: {}
- name: fq_off
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl_tab@0: 0,0,1,1'
    label: F Offset
    orient: Qt.Horizontal
    start: '0'
    step: '0.1e-3'
    stop: '3e-3'
    value: '0e-3'
  states: {}
- name: frame_dur
  id: variable_qtgui_label
  parameters:
    gui_hint: 'demod_tab@1: 1,0,1,1'
    label: Frame Duration
    type: real
    value: 1. * frame_len / samp_rate
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: window_len + len(preamble)
  states: {}
- name: gfdm_constellation
  id: variable_constellation
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]'
    precision: '8'
    type: qpsk
  states: {}
- name: ic_iter_range
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl_tab@0: 3,0,1,1'
    label: IC Iterations
    min_len: '50'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '256'
    value: '2'
  states: {}
- name: interleaver_indices
  id: variable
  parameters:
    value: np.random.permutation(bits_per_frame)
  states: {}
- name: modulated_preambles
  id: variable
  parameters:
    value: pre_module.mapped_preamble(seed, 'rrc', .2, active_subcarriers, subcarriers, subcarrier_map, overlap, cp_len, ramp_len)
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl_tab@0: 1,0,1,1'
    label: Noise
    orient: Qt.Horizontal
    start: '0'
    step: '0.005'
    stop: '1'
    value: '0.01'
  states: {}
- name: overlap
  id: variable
  parameters:
    value: '2'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: modulated_preambles[0]
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: len(preamble)
  states: {}
- name: ramp_len
  id: variable
  parameters:
    value: cs_len
  states: {}
- name: rx_f_taps
  id: variable
  parameters:
    value: np.conjugate(f_taps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3.125e6 * 1
  states: {}
- name: seed
  id: variable
  parameters:
    value: utils.generate_seed('awesome preamble')
  states: {}
- name: subcarrier_map
  id: variable
  parameters:
    value: mapping.get_subcarrier_map(subcarriers, active_subcarriers, dc_free=True)
  states: {}
- name: subcarriers
  id: variable
  parameters:
    value: '64'
  states: {}
- name: timeslots
  id: variable
  parameters:
    value: '9'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 'demod_tab@1: 0,0,1,1'
    label: Block length
    type: int
    value: block_len
  states: {}
- name: window_len
  id: variable
  parameters:
    value: block_len + cp_len + cs_len
  states: {}
- name: window_taps
  id: variable
  parameters:
    value: cyclic_prefix.get_raised_cosine_ramp(ramp_len, cyclic_prefix.get_window_len(cp_len, timeslots, subcarriers, cs_len))
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '2048'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.0'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: gfdm_constellation.bits_per_symbol()
    len_tag_key: ''
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"frame_start"'
    packet_len: frame_len
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: fq_off
    noise_voltage: noise_voltage
    seed: '0'
    taps: chan_taps / np.sqrt(np.linalg.norm(chan_taps))
  states: {}
- name: ctrl_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,4,2,1
    label0: Simulation Control
    num_tabs: '1'
  states: {}
- name: demod_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,3,4
    label0: Demodulation
    label1: Stats
    num_tabs: '2'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: gfdm_constellation.points()
  states: {}
- name: hier_gfdm_receiver_tagged_0
  id: hier_gfdm_receiver_tagged
  parameters:
    active_subcarriers: active_subcarriers
    compensate_phase: '0'
    cp_len: cp_len
    cs_len: cs_len
    frame_len: frame_len
    frame_start_tag_key: '"frame_start"'
    gfdm_constellation: digital.constellation_qpsk().base()
    ic_iterations: ic_iter_range
    overlap: overlap
    preamble: modulated_preambles[1]
    ramp_len: ramp_len
    rx_filter_taps: rx_f_taps
    subcarrier_map: subcarrier_map
    subcarriers: subcarriers
    timeslots: timeslots
    which_estimator: '1'
  states: {}
- name: hier_gfdm_transmitter_0
  id: hier_gfdm_transmitter
  parameters:
    active_subcarriers: active_subcarriers
    cp_len: cp_len
    cs_len: cs_len
    filter_taps: f_taps
    overlap: overlap
    preamble: preamble
    ramp_len: ramp_len
    subcarrier_map: subcarrier_map
    subcarriers: subcarriers
    timeslots: timeslots
    window_taps: window_taps
  states: {}
- name: import_cyclic_prefix
  id: import
  parameters:
    imports: from gfdm.pygfdm import cyclic_prefix
  states: {}
- name: import_cyclic_prefix_0
  id: import
  parameters:
    imports: from gfdm.pygfdm import utils
  states: {}
- name: import_filters
  id: import
  parameters:
    imports: from gfdm.pygfdm import filters
  states: {}
- name: import_mapping
  id: import
  parameters:
    imports: from gfdm.pygfdm import mapping
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_synchronization
  id: import
  parameters:
    imports: from gfdm.pygfdm import preamble as pre_module
  states: {}
- name: import_validation
  id: import
  parameters:
    imports: from gfdm.pygfdm import validation_utils as vu
  states: {}
- name: polarwrap_bit_interleaver_bb_0
  id: polarwrap_bit_interleaver_bb
  parameters:
    interleaver_indices: np.arange(bits_per_frame)
    is_packed: '1'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"green"'
    grid: 'True'
    gui_hint: 'demod_tab@0: 0,0,2,2'
    legend: 'False'
    name: '"RX Constellation"'
    size: timeslots * active_subcarriers
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 'sync_tab@0: 2, 0, 1,1'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'sync_tab@0: 1, 0, 1,1'
    label1: ''
    label2: ''
    legend: 'False'
    name: '"Frame-synchronized bursts"'
    size: frame_len * 4
    srate: samp_rate
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.1'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'demod_tab@0: 0, 2, 2, 2'
    label1: Re{estimate}
    label2: Im{estimate}
    name: '"Channel Estimate"'
    size: block_len
    srate: samp_rate * 0 + 1
    tr_level: '0.05'
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.1'
    width1: '4'
    width2: '4'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: sync_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,4,5
    label0: Synchronization
    num_tabs: '1'
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_char_to_float_0, '0']
- [analog_random_source_x_0, '0', polarwrap_bit_interleaver_bb_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', hier_gfdm_receiver_tagged_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', hier_gfdm_transmitter_0, '0']
- [hier_gfdm_receiver_tagged_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [hier_gfdm_receiver_tagged_0, '1', qtgui_const_sink_x_0, '0']
- [hier_gfdm_transmitter_0, '0', blocks_multiply_const_vxx_0, '0']
- [polarwrap_bit_interleaver_bb_0, '0', blocks_char_to_float_0_0, '0']
- [polarwrap_bit_interleaver_bb_0, '0', blocks_repack_bits_bb_0, '0']

metadata:
  file_format: 1
