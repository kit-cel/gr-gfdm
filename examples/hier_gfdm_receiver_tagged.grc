options:
  parameters:
    author: Johannes Demel
    category: '[GFDM]'
    generate_options: hb
    id: hier_gfdm_receiver_tagged
    output_language: python
    title: GFDM Receiver tagged
  states: {}

blocks:
- name: block_len
  id: variable
  parameters:
    value: timeslots * subcarriers
  states: {}
- name: modulated_preambles
  id: variable
  parameters:
    value: pre_module.mapped_preamble(seed, 'rrc', .2, active_subcarriers, subcarriers, subcarrier_map, overlap, cp_len, ramp_len)
  states: {}
- name: preamble
  id: variable
  parameters:
    value: modulated_preambles[0]
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: len(preamble)
  states: {}
- name: seed
  id: variable
  parameters:
    value: utils.generate_seed('awesome preamble')
  states: {}
- name: active_subcarriers
  id: parameter
  parameters:
    type: intx
    value: '52'
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: np.exp(1.j * phase_shift)
    minoutbuf: frame_len
    type: complex
  states: {}
- name: chan
  id: pad_sink
  parameters:
    label: Channel Estimate
    optional: 'True'
    type: complex
  states: {}
- name: compensate_phase
  id: parameter
  parameters:
    label: Do phase compensation
    type: intx
    value: '0'
  states: {}
- name: cp_len
  id: parameter
  parameters:
    label: CP length
    type: intx
    value: '32'
  states: {}
- name: frame_len
  id: parameter
  parameters:
    type: intx
    value: '800'
  states: {}
- name: frame_start_tag_key
  id: parameter
  parameters:
    type: str
    value: '"frame_start"'
  states: {}
- name: gfdm_advanced_receiver_sb_cc_0_0
  id: gfdm_advanced_receiver_sb_cc
  parameters:
    constellation: gfdm_constellation
    do_phase_compensation: compensate_phase
    frequency_taps: rx_filter_taps
    ic_iter: ic_iterations
    minoutbuf: block_len
    overlap: overlap
    subcarrier_map: subcarrier_map
    subcarriers: subcarriers
    timeslots: timeslots
  states: {}
- name: gfdm_channel_estimator_cc_0
  id: gfdm_channel_estimator_cc
  parameters:
    active_subcarriers: active_subcarriers
    fft_len: subcarriers
    is_dc_free: 'True'
    minoutbuf: block_len
    preamble: modulated_preambles[1]
    timeslots: timeslots
    which_estimator: which_estimator
  states: {}
- name: gfdm_constellation
  id: parameter
  parameters:
    value: digital.constellation_qpsk().base()
  states: {}
- name: gfdm_remove_prefix_cc_0
  id: gfdm_remove_prefix_cc
  parameters:
    block_len: len(modulated_preambles[1])
    frame_len: frame_len
    gfdm_sync_tag_key: frame_start_tag_key
    minoutbuf: len(modulated_preambles[1])
    offset: cp_len
  states: {}
- name: gfdm_remove_prefix_cc_0_0
  id: gfdm_remove_prefix_cc
  parameters:
    block_len: block_len
    frame_len: frame_len
    gfdm_sync_tag_key: frame_start_tag_key
    minoutbuf: block_len
    offset: preamble_len + cp_len
  states: {}
- name: gfdm_resource_demapper_cc_0_0
  id: gfdm_resource_demapper_cc
  parameters:
    active_subcarriers: active_subcarriers
    minoutbuf: timeslots * active_subcarriers
    per_timeslot: 'True'
    subcarrier_map: subcarrier_map
    subcarriers: subcarriers
    timeslots: timeslots
  states: {}
- name: ic_iterations
  id: parameter
  parameters:
    value: '2'
  states: {}
- name: import_cyclic_prefix_0
  id: import
  parameters:
    imports: from gfdm.pygfdm import utils
  states: {}
- name: import_digital
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_synchronization
  id: import
  parameters:
    imports: from gfdm.pygfdm import preamble as pre_module
  states: {}
- name: overlap
  id: parameter
  parameters:
    type: intx
    value: '2'
  states: {}
- name: pad_sink_out
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: phase_shift
  id: parameter
  parameters:
    label: Phase shift
    type: eng_float
    value: '0.0'
  states: {}
- name: ramp_len
  id: parameter
  parameters:
    label: Ramp length
    type: intx
    value: '16'
  states: {}
- name: rx_filter_taps
  id: parameter
  parameters:
    value: np.ones(10)
  states: {}
- name: subcarrier_map
  id: parameter
  parameters:
    value: np.arange(52)
  states: {}
- name: subcarriers
  id: parameter
  parameters:
    type: intx
    value: '64'
  states: {}
- name: timeslots
  id: parameter
  parameters:
    type: intx
    value: '5'
  states: {}
- name: which_estimator
  id: parameter
  parameters:
    label: Estimator Type
    type: intx
    value: '0'
  states: {}

connections:
- [blocks_multiply_const_vxx_0_1, '0', gfdm_advanced_receiver_sb_cc_0_0, '0']
- [gfdm_advanced_receiver_sb_cc_0_0, '0', gfdm_resource_demapper_cc_0_0, '0']
- [gfdm_channel_estimator_cc_0, '0', chan, '0']
- [gfdm_channel_estimator_cc_0, '0', gfdm_advanced_receiver_sb_cc_0_0, '1']
- [gfdm_remove_prefix_cc_0, '0', gfdm_channel_estimator_cc_0, '0']
- [gfdm_remove_prefix_cc_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [gfdm_resource_demapper_cc_0_0, '0', pad_sink_out, '0']
- [pad_source_0, '0', gfdm_remove_prefix_cc_0, '0']
- [pad_source_0, '0', gfdm_remove_prefix_cc_0_0, '0']

metadata:
  file_format: 1
