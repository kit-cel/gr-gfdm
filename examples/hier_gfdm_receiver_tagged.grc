<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hier_gfdm_receiver_tagged</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>[GFDM]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>GFDM Receiver tagged</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block_len</value></param>
<param><key>value</key><value>timeslots * subcarriers</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_preambles</value></param>
<param><key>value</key><value>pre_module.mapped_preamble(seed, 'rrc', .2, active_subcarriers, subcarriers, subcarrier_map, overlap, cp_len, ramp_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>modulated_preambles[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>value</key><value>len(preamble)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>seed</value></param>
<param><key>value</key><value>utils.generate_seed('awesome preamble')</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>active_subcarriers</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>52</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>chan</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>Channel Estimate</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>compensate_phase</value></param>
<param><key>label</key><value>Do phase compensation</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>label</key><value>CP length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>800</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_start_tag_key</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>frame_start</value></param>
</block>
<block>
<key>gfdm_advanced_receiver_sb_cc</key>
<param><key>id</key><value>gfdm_advanced_receiver_sb_cc_0_0</value></param>
<param><key>constellation</key><value>gfdm_constellation</value></param>
<param><key>do_phase_compensation</key><value>compensate_phase</value></param>
<param><key>frequency_taps</key><value>rx_filter_taps</value></param>
<param><key>ic_iter</key><value>ic_iterations</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
<param><key>minoutbuf</key><value>block_len</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
</block>
<block>
<key>gfdm_channel_estimator_cc</key>
<param><key>id</key><value>gfdm_channel_estimator_cc_0</value></param>
<param><key>active_subcarriers</key><value>active_subcarriers</value></param>
<param><key>which_estimator</key><value>which_estimator</value></param>
<param><key>fft_len</key><value>subcarriers</value></param>
<param><key>minoutbuf</key><value>block_len</value></param>
<param><key>preamble</key><value>modulated_preambles[1]</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
<param><key>is_dc_free</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gfdm_constellation</value></param>
<param><key>value</key><value>digital.constellation_qpsk().base()</value></param>
</block>
<block>
<key>gfdm_remove_prefix_cc</key>
<param><key>id</key><value>gfdm_remove_prefix_cc_0</value></param>
<param><key>block_len</key><value>len(modulated_preambles[1])</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>minoutbuf</key><value>len(modulated_preambles[1])</value></param>
<param><key>offset</key><value>cp_len</value></param>
<param><key>gfdm_sync_tag_key</key><value>frame_start_tag_key</value></param>
</block>
<block>
<key>gfdm_remove_prefix_cc</key>
<param><key>id</key><value>gfdm_remove_prefix_cc_0_0</value></param>
<param><key>block_len</key><value>block_len</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>minoutbuf</key><value>block_len</value></param>
<param><key>offset</key><value>preamble_len + cp_len</value></param>
<param><key>gfdm_sync_tag_key</key><value>frame_start_tag_key</value></param>
</block>
<block>
<key>gfdm_resource_demapper_cc</key>
<param><key>id</key><value>gfdm_resource_demapper_cc_0_0</value></param>
<param><key>active_subcarriers</key><value>active_subcarriers</value></param>
<param><key>minoutbuf</key><value>timeslots * active_subcarriers</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>per_timeslot</key><value>True</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ic_iterations</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_cyclic_prefix_0</value></param>
<param><key>import</key><value>from gfdm.pygfdm import utils</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_digital</value></param>
<param><key>import</key><value>from gnuradio import digital</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_numpy</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_synchronization</value></param>
<param><key>import</key><value>from gfdm.pygfdm import preamble as pre_module</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>overlap</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ramp_len</value></param>
<param><key>label</key><value>Ramp length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_filter_taps</value></param>
<param><key>value</key><value>np.ones(10)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarrier_map</value></param>
<param><key>value</key><value>np.arange(52)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>timeslots</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>which_estimator</value></param>
<param><key>label</key><value>Estimator Type</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>gfdm_advanced_receiver_sb_cc_0_0</source_block_id><sink_block_id>gfdm_resource_demapper_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_channel_estimator_cc_0</source_block_id><sink_block_id>chan</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_channel_estimator_cc_0</source_block_id><sink_block_id>gfdm_advanced_receiver_sb_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gfdm_remove_prefix_cc_0</source_block_id><sink_block_id>gfdm_channel_estimator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_remove_prefix_cc_0_0</source_block_id><sink_block_id>gfdm_advanced_receiver_sb_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_resource_demapper_cc_0_0</source_block_id><sink_block_id>pad_sink_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>gfdm_remove_prefix_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>gfdm_remove_prefix_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
