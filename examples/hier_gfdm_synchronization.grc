<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gfdm_synchronization</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>[GFDM]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>GFDM Synchronization</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>energy_burst_tag</value></param>
<param><key>value</key><value>'energy_start'</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>burst_backoff</value></param>
<param><key>label</key><value>Burst Backoff</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>label</key><value>CP length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>dbg_cfo</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>dbg_energy_bursts</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>energy_bursts</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>label</key><value>Frame length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>800</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>frames</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>gfdm_extract_burst_cc</key>
<param><key>id</key><value>gfdm_extract_burst_cc_0</value></param>
<param><key>burst_start_tag</key><value>energy_burst_tag</value></param>
<param><key>burst_len</key><value>int(1.25 * frame_len)</value></param>
</block>
<block>
<key>gfdm_simple_preamble_sync_cc</key>
<param><key>id</key><value>gfdm_simple_preamble_sync_cc_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>in_key</key><value>energy_burst_tag</value></param>
<param><key>out_key</key><value>output_tag_key</value></param>
<param><key>preamble</key><value>ref_preamble</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
</block>
<block>
<key>hier_energy_burst_detector</key>
<param><key>id</key><value>hier_energy_burst_detector_0</value></param>
<param><key>burst_backoff</key><value>burst_backoff</value></param>
<param><key>burst_tag_key</key><value>energy_burst_tag</value></param>
<param><key>peak_look_ahead_value</key><value>look_ahead_val</value></param>
<param><key>peak_th_factor</key><value>peak_rise_factor</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_numpy</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>look_ahead_val</value></param>
<param><key>label</key><value>Energy Look Ahead</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_tag_key</value></param>
<param><key>label</key><value>Frame Tag Key</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>frame_start</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>peak_rise_factor</value></param>
<param><key>label</key><value>Peak TH Factor Rise</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10.</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ref_preamble</value></param>
<param><key>label</key><value>Preamble</value></param>
<param><key>value</key><value>np.ones(256)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>label</key><value>Subcarriers</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<connection><source_block_id>gfdm_extract_burst_cc_0</source_block_id><sink_block_id>gfdm_simple_preamble_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>dbg_cfo</sink_block_id><source_key>cfo</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>frames</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_energy_burst_detector_0</source_block_id><sink_block_id>dbg_energy_bursts</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_energy_burst_detector_0</source_block_id><sink_block_id>gfdm_extract_burst_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>hier_energy_burst_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
