<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gfdm_ota_demo</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>GFDM over-the-air Demo</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>active_subcarriers</value></param>
<param><key>value</key><value>52</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>active_symbols</value></param>
<param><key>value</key><value>timeslots * active_subcarriers</value></param>
<param><key>gui_hint</key><value>demod_tab@1: 0,1,1,1</value></param>
<param><key>label</key><value>Active Symbols</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>bits_per_frame</value></param>
<param><key>value</key><value>int(np.log2(len(gfdm_constellation.points() ) )) * active_symbols</value></param>
<param><key>gui_hint</key><value>demod_tab@1: 0,2,1,1</value></param>
<param><key>label</key><value>Num bits</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block_len</value></param>
<param><key>value</key><value>timeslots * fft_len</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>burst_backoff</value></param>
<param><key>value</key><value>look_ahead_val</value></param>
<param><key>gui_hint</key><value>7, 3,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>8 * look_ahead_val</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>value</key><value>fft_len // 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_len</value></param>
<param><key>value</key><value>cp_len // 2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>data_rate</value></param>
<param><key>value</key><value>int(1000. * bits_per_frame)</value></param>
<param><key>gui_hint</key><value>demod_tab@1: 0,2,1,1</value></param>
<param><key>label</key><value>Data Rate</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_taps</value></param>
<param><key>value</key><value>filters.get_frequency_domain_filter('rrc', .2, timeslots, fft_len, overlap)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>frame_dur</value></param>
<param><key>value</key><value>1. * frame_len / samp_rate</value></param>
<param><key>gui_hint</key><value>demod_tab@1: 1,0,1,1</value></param>
<param><key>label</key><value>Frame Duration</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_gap</value></param>
<param><key>value</key><value>np.zeros(int(1. * samp_rate / 1000.) - frame_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>value</key><value>window_len + len(preamble)</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>gfdm_constellation</value></param>
<param><key>const_points</key><value>[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ic_iter_range</value></param>
<param><key>value</key><value>2</value></param>
<param><key>gui_hint</key><value>8,3,1,1</value></param>
<param><key>label</key><value>IC Iterations</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>256</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>look_ahead_val</value></param>
<param><key>value</key><value>cp_len * 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_preambles</value></param>
<param><key>value</key><value>pre_module.mapped_preamble(seed, 'rrc', .2, active_subcarriers, fft_len, subcarrier_map, overlap, cp_len, ramp_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>my_ref</value></param>
<param><key>value</key><value>vu.generate_reference_frame(timeslots, fft_len, active_subcarriers, cp_len, cs_len, .2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>overlap</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>peak_rise_factor</value></param>
<param><key>value</key><value>10.</value></param>
<param><key>label</key><value>Peak TH Factor Rise</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>modulated_preambles[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>value</key><value>len(preamble)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ramp_len</value></param>
<param><key>value</key><value>cs_len</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rgain</value></param>
<param><key>value</key><value>40.</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>70</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_f_taps</value></param>
<param><key>value</key><value>np.conjugate(f_taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3.125e6 * 8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>seed</value></param>
<param><key>value</key><value>utils.generate_seed('awesome preamble')</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subcarrier_map</value></param>
<param><key>value</key><value>mapping.get_subcarrier_map(fft_len, active_subcarriers, dc_free=True)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_preamble</value></param>
<param><key>value</key><value>modulated_preambles[1]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tfreq</value></param>
<param><key>value</key><value>2.4805e9</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2.46e9</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>2.490e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tgain</value></param>
<param><key>value</key><value>20.</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>70</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeslots</value></param>
<param><key>value</key><value>21</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>block_len</value></param>
<param><key>gui_hint</key><value>demod_tab@1: 0,0,1,1</value></param>
<param><key>label</key><value>Block length</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_len</value></param>
<param><key>value</key><value>block_len + cp_len + cs_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_taps</value></param>
<param><key>value</key><value>cyclic_prefix.get_raised_cosine_ramp(ramp_len, cyclic_prefix.get_window_len(cp_len, timeslots, fft_len, cs_len))</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>len(gfdm_constellation.points())</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>2048</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_burst_tagger</key>
<param><key>id</key><value>blocks_burst_tagger_0_0</value></param>
<param><key>false_key</key><value>E</value></param>
<param><key>false_value</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>true_key</key><value>energy_start</value></param>
<param><key>true_value</key><value>True</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_short</key>
<param><key>id</key><value>blocks_char_to_short_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>fft_len + cp_len * 3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>2.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_plateau_detector_fb</key>
<param><key>id</key><value>blocks_plateau_detector_fb_0</value></param>
<param><key>max_len</key><value>int(1.5 * cp_len)</value></param>
<param><key>threshold</key><value>.4</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>my_ref[0]</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>utils.get_pseudo_random_bytes(0, 4, active_subcarriers * timeslots, 'awesome frame')</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>utils.get_random_qpsk(timeslots * active_subcarriers, utils.generate_seed('awesome frame'))</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>demod_tab</value></param>
<param><key>gui_hint</key><value>0,0,3,4</value></param>
<param><key>label0</key><value>Demodulation</value></param>
<param><key>label1</key><value>Stats</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>gfdm_constellation.points()</value></param>
</block>
<block>
<key>blocks_vector_insert_x</key>
<param><key>id</key><value>frame_gap_vector_insert</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>period</key><value>frame_len + len(frame_gap)</value></param>
<param><key>vector</key><value>frame_gap</value></param>
</block>
<block>
<key>gfdm_advanced_receiver_sb_cc</key>
<param><key>id</key><value>gfdm_advanced_receiver_sb_cc_0</value></param>
<param><key>constellation</key><value>gfdm_constellation</value></param>
<param><key>frequency_taps</key><value>rx_f_taps</value></param>
<param><key>ic_iter</key><value>ic_iter_range</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
<param><key>subcarriers</key><value>fft_len</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
</block>
<block>
<key>gfdm_channel_estimator_cc</key>
<param><key>id</key><value>gfdm_channel_estimator_cc_0</value></param>
<param><key>active_subcarriers</key><value>active_subcarriers</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>preamble</key><value>modulated_preambles[1]</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
<param><key>is_dc_free</key><value>True</value></param>
</block>
<block>
<key>gfdm_extract_burst_cc</key>
<param><key>id</key><value>gfdm_extract_burst_cc_0</value></param>
<param><key>burst_start_tag</key><value>energy_start</value></param>
<param><key>burst_len</key><value>int(1.25 * frame_len)</value></param>
</block>
<block>
<key>gfdm_remove_prefix_cc</key>
<param><key>id</key><value>gfdm_remove_prefix_cc_0</value></param>
<param><key>block_len</key><value>len(modulated_preambles[1])</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>offset</key><value>cp_len</value></param>
<param><key>gfdm_sync_tag_key</key><value>frame_start</value></param>
</block>
<block>
<key>gfdm_remove_prefix_cc</key>
<param><key>id</key><value>gfdm_remove_prefix_cc_0_0</value></param>
<param><key>block_len</key><value>block_len</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>offset</key><value>preamble_len + cp_len</value></param>
<param><key>gfdm_sync_tag_key</key><value>frame_start</value></param>
</block>
<block>
<key>gfdm_resource_demapper_cc</key>
<param><key>id</key><value>gfdm_resource_demapper_cc_0</value></param>
<param><key>active_subcarriers</key><value>active_subcarriers</value></param>
<param><key>subcarriers</key><value>fft_len</value></param>
<param><key>per_timeslot</key><value>True</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
</block>
<block>
<key>gfdm_simple_preamble_sync_cc</key>
<param><key>id</key><value>gfdm_simple_preamble_sync_cc_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>in_key</key><value>energy_start</value></param>
<param><key>out_key</key><value>frame_start</value></param>
<param><key>preamble</key><value>sync_preamble</value></param>
<param><key>subcarriers</key><value>fft_len</value></param>
</block>
<block>
<key>hier_gfdm_transmitter</key>
<param><key>id</key><value>hier_gfdm_transmitter_0</value></param>
<param><key>active_subcarriers</key><value>active_subcarriers</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>cs_len</key><value>cs_len</value></param>
<param><key>filter_taps</key><value>f_taps</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>preamble</key><value>preamble</value></param>
<param><key>ramp_len</key><value>ramp_len</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
<param><key>subcarriers</key><value>fft_len</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
<param><key>window_taps</key><value>window_taps</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_cyclic_prefix</value></param>
<param><key>import</key><value>from gfdm.pygfdm import cyclic_prefix</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_cyclic_prefix_0</value></param>
<param><key>import</key><value>from gfdm.pygfdm import utils</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_filters</value></param>
<param><key>import</key><value>from gfdm.pygfdm import filters</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_mapping</value></param>
<param><key>import</key><value>from gfdm.pygfdm import mapping</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_numpy</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_synchronization</value></param>
<param><key>import</key><value>from gfdm.pygfdm import preamble as pre_module</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_validation</value></param>
<param><key>import</key><value>from gfdm.pygfdm import validation_utils as vu</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>demod_tab@0: 0,0,3,3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"green"</value></param>
<param><key>name</key><value>"RX Constellation"</value></param>
<param><key>size</key><value>timeslots * active_subcarriers</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>len(my_ref[0])</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>sync_tab@0: 0, 0, 1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value></value></param>
<param><key>color6</key><value>"magenta"</value></param>
<param><key>label6</key><value></value></param>
<param><key>name</key><value>"Energy-detected bursts"</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>frame_len * 12</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.05</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>tr_tag</key><value>"energy_start"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>sync_tab@0: 1, 0, 1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Frame-synchronized bursts"</value></param>
<param><key>size</key><value>frame_len * 4</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.05</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"frame_start"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_1</value></param>
<param><key>gui_hint</key><value>demod_tab@0: 0, 3, 1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"yellow"</value></param>
<param><key>label1</key><value>Re{estimate}</value></param>
<param><key>width1</key><value>4</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Im{estimate}</value></param>
<param><key>width2</key><value>4</value></param>
<param><key>name</key><value>"Channel Estimate"</value></param>
<param><key>size</key><value>block_len</value></param>
<param><key>srate</key><value>samp_rate * 0 + 1</value></param>
<param><key>tr_level</key><value>0.05</value></param>
<param><key>tr_tag</key><value>"frame_start"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_2</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>sync_tab@0: 0, 0, 1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>name</key><value>"Energy-detected bursts"</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>frame_len * 12</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.05</value></param>
<param><key>tr_tag</key><value>"energy_start"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>schmidl_and_cox_preamble_detector</key>
<param><key>id</key><value>schmidl_and_cox_preamble_detector_0</value></param>
<param><key>p_len</key><value>len(sync_preamble)</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>sync_tab</value></param>
<param><key>gui_hint</key><value>3,0,4,4</value></param>
<param><key>label0</key><value>Synchronization</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>tfreq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tgain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.7"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>tfreq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rgain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.5"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_burst_tagger_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_burst_tagger_0_0</source_block_id><sink_block_id>gfdm_extract_burst_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_char_to_short_0</source_block_id><sink_block_id>blocks_burst_tagger_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_burst_tagger_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>frame_gap_vector_insert</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_plateau_detector_fb_0</source_block_id><sink_block_id>blocks_char_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_plateau_detector_fb_0</source_block_id><sink_block_id>blocks_char_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0_0</source_block_id><sink_block_id>hier_gfdm_transmitter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>hier_gfdm_transmitter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frame_gap_vector_insert</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_advanced_receiver_sb_cc_0</source_block_id><sink_block_id>gfdm_resource_demapper_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_channel_estimator_cc_0</source_block_id><sink_block_id>gfdm_advanced_receiver_sb_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gfdm_channel_estimator_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_extract_burst_cc_0</source_block_id><sink_block_id>gfdm_simple_preamble_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_remove_prefix_cc_0</source_block_id><sink_block_id>gfdm_channel_estimator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_remove_prefix_cc_0_0</source_block_id><sink_block_id>gfdm_advanced_receiver_sb_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_resource_demapper_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>gfdm_remove_prefix_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>gfdm_remove_prefix_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_gfdm_transmitter_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_gfdm_transmitter_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>schmidl_and_cox_preamble_detector_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>schmidl_and_cox_preamble_detector_0</source_block_id><sink_block_id>blocks_plateau_detector_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>schmidl_and_cox_preamble_detector_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>schmidl_and_cox_preamble_detector_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>schmidl_and_cox_preamble_detector_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>schmidl_and_cox_preamble_detector_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>schmidl_and_cox_preamble_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
