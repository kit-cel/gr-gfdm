<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gfdm_fast_sync_demo</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>max_nouts</key><value>1024</value></param>
<param><key>title</key><value>GFDM Fast Sync</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>active_subcarriers</value></param>
<param><key>value</key><value>52</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>active_symbols</value></param>
<param><key>value</key><value>timeslots * active_subcarriers</value></param>
<param><key>gui_hint</key><value>demod_tab@1: 0,1,1,1</value></param>
<param><key>label</key><value>Active Symbols</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>bits_per_frame</value></param>
<param><key>value</key><value>int(np.log2(len(gfdm_constellation.points() ) )) * active_symbols</value></param>
<param><key>gui_hint</key><value>demod_tab@1: 0,2,1,1</value></param>
<param><key>label</key><value>Num bits</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block_len</value></param>
<param><key>value</key><value>timeslots * fft_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bytes_per_frame</value></param>
<param><key>value</key><value>int(bits_per_frame // 8)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>chan_epsilon</value></param>
<param><key>value</key><value>1.</value></param>
<param><key>gui_hint</key><value>ctrl_tab@0: 2, 0, 1,1</value></param>
<param><key>label</key><value>epsilon</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1./samp_rate</value></param>
<param><key>stop</key><value>10.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_taps</value></param>
<param><key>value</key><value>[1. + 1.j, .7 - .1j, .1 + .01j, 0.04+.05j, 0.1+0.01j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>value</key><value>fft_len // 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_len</value></param>
<param><key>value</key><value>cp_len // 2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>data_rate</value></param>
<param><key>value</key><value>int(1000. * bits_per_frame)</value></param>
<param><key>gui_hint</key><value>demod_tab@1: 0,3,1,1</value></param>
<param><key>label</key><value>Data Rate</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_taps</value></param>
<param><key>value</key><value>filters.get_frequency_domain_filter('rrc', .2, timeslots, fft_len, overlap)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fq_off</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>gui_hint</key><value>ctrl_tab@0: 1, 0, 1,1</value></param>
<param><key>label</key><value>F Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10.e4</value></param>
<param><key>step</key><value>1.</value></param>
<param><key>stop</key><value>10.e4</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>frame_dur</value></param>
<param><key>value</key><value>1. * frame_len / samp_rate</value></param>
<param><key>gui_hint</key><value>demod_tab@1: 1,0,1,1</value></param>
<param><key>label</key><value>Frame Duration</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_gap</value></param>
<param><key>value</key><value>np.zeros(int(1. * samp_rate / 1000.) - frame_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>value</key><value>window_len + len(preamble)</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>gfdm_constellation</value></param>
<param><key>const_points</key><value>[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ic_iter_range</value></param>
<param><key>value</key><value>4</value></param>
<param><key>gui_hint</key><value>ctrl_tab@0:3,0,1,1</value></param>
<param><key>label</key><value>IC Iterations</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>256</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_preambles</value></param>
<param><key>value</key><value>pre_module.mapped_preamble(seed, 'rrc', .2, active_subcarriers, fft_len, subcarrier_map, overlap, cp_len, ramp_len)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_voltage</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>gui_hint</key><value>ctrl_tab@0: 0,0,1,1</value></param>
<param><key>label</key><value>Noise</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>overlap</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>modulated_preambles[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>value</key><value>len(preamble)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ramp_len</value></param>
<param><key>value</key><value>cs_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_f_taps</value></param>
<param><key>value</key><value>np.conjugate(f_taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3.125e6 * 8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>seed</value></param>
<param><key>value</key><value>utils.generate_seed('awesome preamble')</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subcarrier_map</value></param>
<param><key>value</key><value>mapping.get_subcarrier_map(fft_len, active_subcarriers, dc_free=True)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeslots</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>block_len</value></param>
<param><key>gui_hint</key><value>demod_tab@1: 0,0,1,1</value></param>
<param><key>label</key><value>Block length</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0</value></param>
<param><key>value</key><value>samp_rate / fft_len</value></param>
<param><key>gui_hint</key><value>demod_tab@1: 1,1,1,1</value></param>
<param><key>label</key><value>subcarrier spacing</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_len</value></param>
<param><key>value</key><value>block_len + cp_len + cs_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_taps</value></param>
<param><key>value</key><value>cyclic_prefix.get_raised_cosine_ramp(ramp_len, cyclic_prefix.get_window_len(cp_len, timeslots, fft_len, cs_len))</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>1e-2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>len(preamble) * 2 + cp_len - 1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>4.</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>2.0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>1</value></param>
<param><key>maxsize</key><value>bytes_per_frame - 20</value></param>
<param><key>minsize</key><value>bytes_per_frame - 20</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>gfdm_constellation.bits_per_symbol()</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>gfdm_constellation.bits_per_symbol()</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"rx_len"</value></param>
<param><key>packet_len</key><value>bytes_per_frame</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>chan_epsilon</value></param>
<param><key>freq_offset</key><value>1. * fq_off / samp_rate</value></param>
<param><key>noise_voltage</key><value>noise_voltage</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>chan_taps / np.sqrt(np.linalg.norm(chan_taps))</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>ctrl_tab</value></param>
<param><key>gui_hint</key><value>3,4,2,1</value></param>
<param><key>label0</key><value>Simulation Control</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>demod_tab</value></param>
<param><key>gui_hint</key><value>0,0,2,5</value></param>
<param><key>label0</key><value>Demodulation</value></param>
<param><key>label1</key><value>Stats</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>gfdm_constellation.points()</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>gfdm_constellation.base()</value></param>
</block>
<block>
<key>blocks_vector_insert_x</key>
<param><key>id</key><value>frame_gap_vector_insert</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>period</key><value>frame_len + len(frame_gap)</value></param>
<param><key>vector</key><value>frame_gap</value></param>
</block>
<block>
<key>gfdm_remove_prefix_cc</key>
<param><key>id</key><value>gfdm_remove_prefix_cc_0</value></param>
<param><key>block_len</key><value>len(modulated_preambles[1])</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>offset</key><value>cp_len</value></param>
<param><key>gfdm_sync_tag_key</key><value>frame_start</value></param>
</block>
<block>
<key>gfdm_transmitter_cc</key>
<param><key>id</key><value>gfdm_transmitter_cc_0</value></param>
<param><key>active_subcarriers</key><value>active_subcarriers</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>cs_len</key><value>cs_len</value></param>
<param><key>frequency_taps</key><value>f_taps</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>preamble</key><value>preamble</value></param>
<param><key>ramp_len</key><value>ramp_len</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
<param><key>subcarriers</key><value>fft_len</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
<param><key>window_taps</key><value>window_taps</value></param>
<param><key>per_timeslot</key><value>True</value></param>
</block>
<block>
<key>hier_gfdm_fastsync</key>
<param><key>id</key><value>hier_gfdm_fastsync_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>output_tag_key</key><value>"frame_start"</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>ref_preamble</key><value>modulated_preambles[1]</value></param>
<param><key>sc_high_thr</key><value>.7</value></param>
<param><key>sc_low_thr</key><value>.6</value></param>
<param><key>xcorr_det_thr</key><value>10.</value></param>
</block>
<block>
<key>hier_gfdm_receiver_tagged</key>
<param><key>id</key><value>hier_gfdm_receiver_tagged_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>which_estimator</key><value>1</value></param>
<param><key>ramp_len</key><value>ramp_len</value></param>
<param><key>active_subcarriers</key><value>active_subcarriers</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>frame_start_tag_key</key><value>"frame_start"</value></param>
<param><key>gfdm_constellation</key><value>gfdm_constellation</value></param>
<param><key>ic_iterations</key><value>ic_iter_range</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>rx_filter_taps</key><value>rx_f_taps</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
<param><key>subcarriers</key><value>fft_len</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
</block>
<block>
<key>hier_packet_formatter</key>
<param><key>id</key><value>hier_packet_formatter_0</value></param>
<param><key>dst_id</key><value>84</value></param>
<param><key>length_tag_name</key><value>"packet_len"</value></param>
<param><key>src_id</key><value>42</value></param>
</block>
<block>
<key>hier_packet_parser</key>
<param><key>id</key><value>hier_packet_parser_0</value></param>
<param><key>tag_key</key><value>"rx_len"</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_cyclic_prefix</value></param>
<param><key>import</key><value>from gfdm.pygfdm import cyclic_prefix</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_cyclic_prefix_0</value></param>
<param><key>import</key><value>from gfdm.pygfdm import utils</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_filters</value></param>
<param><key>import</key><value>from gfdm.pygfdm import filters</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_mapping</value></param>
<param><key>import</key><value>from gfdm.pygfdm import mapping</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_numpy</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_synchronization</value></param>
<param><key>import</key><value>from gfdm.pygfdm import preamble as pre_module</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_validation</value></param>
<param><key>import</key><value>from gfdm.pygfdm import validation_utils as vu</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>demod_tab@0: 0,0,2,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"green"</value></param>
<param><key>name</key><value>"RX Constellation"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>timeslots * active_subcarriers</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>128</value></param>
<param><key>gui_hint</key><value>demod_tab@0: 0, 2, 2,3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_1</value></param>
<param><key>axislabels</key><value>False</value></param>
<param><key>gui_hint</key><value>demod_tab@0: 0, 2, 2,3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"yellow"</value></param>
<param><key>label1</key><value>Re{estimate}</value></param>
<param><key>width1</key><value>4</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Im{estimate}</value></param>
<param><key>width2</key><value>4</value></param>
<param><key>name</key><value>"Channel Estimate"</value></param>
<param><key>size</key><value>block_len</value></param>
<param><key>srate</key><value>samp_rate * 0 + 1</value></param>
<param><key>tr_level</key><value>0.05</value></param>
<param><key>tr_tag</key><value>"frame_start"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_2_0</value></param>
<param><key>gui_hint</key><value>sync_tab@0: 2, 0, 1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>name</key><value>"Fast Sync"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>frame_len * 12</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_chan</key><value>2</value></param>
<param><key>tr_delay</key><value>2e-5</value></param>
<param><key>tr_level</key><value>0.05</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>frame_start</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>ymax</key><value>.5</value></param>
<param><key>ymin</key><value>-.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_2_0_0</value></param>
<param><key>gui_hint</key><value>sync_tab@0: 1, 0, 1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>name</key><value>"Synced Frames"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>frame_len * 12</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.05</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>frame_start</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>ymax</key><value>.5</value></param>
<param><key>ymin</key><value>-.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_2_0_1</value></param>
<param><key>gui_hint</key><value>sync_tab@0: 0, 0, 1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"bits"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>bytes_per_frame * 4</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.05</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>packet_len</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>ylabel</key><value>value</value></param>
<param><key>ymax</key><value>160</value></param>
<param><key>ymin</key><value>-160</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>128</value></param>
<param><key>gui_hint</key><value>demod_tab@0: 0, 2, 2,3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>sync_tab</value></param>
<param><key>gui_hint</key><value>3,0,4,4</value></param>
<param><key>label0</key><value>Synchronization</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>hier_gfdm_fastsync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_2_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>frame_gap_vector_insert</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>hier_packet_formatter_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>hier_packet_parser_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>hier_gfdm_fastsync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>gfdm_transmitter_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frame_gap_vector_insert</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>frame_gap_vector_insert</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frame_gap_vector_insert</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_remove_prefix_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_remove_prefix_cc_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_transmitter_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_transmitter_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>hier_gfdm_fastsync_0</source_block_id><sink_block_id>gfdm_remove_prefix_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_gfdm_fastsync_0</source_block_id><sink_block_id>hier_gfdm_receiver_tagged_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_gfdm_fastsync_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_gfdm_fastsync_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_2_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>hier_gfdm_receiver_tagged_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_gfdm_receiver_tagged_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_gfdm_receiver_tagged_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>hier_packet_formatter_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_packet_formatter_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_packet_parser_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdu</source_key><sink_key>print_pdu</sink_key></connection>
</flow_graph>
