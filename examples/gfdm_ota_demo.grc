options:
  parameters:
    author: Johannes Demel
    generate_options: qt_gui
    id: gfdm_ota_demo
    max_nouts: '1024'
    output_language: python
    realtime_scheduling: '1'
    title: GFDM over-the-air Demo
  states: {}

blocks:
- name: activate_cfo_compensation
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: ctrl_tab@1:2,0,1,1
    label: compensate CFO
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: bits_per_frame
  id: variable
  parameters:
    value: constel_order * timeslots * active_subcarriers
  states: {}
- name: bytes_per_frame
  id: variable
  parameters:
    value: int(bits_per_frame // 8)
  states: {}
- name: conf
  id: variable
  parameters:
    value: configuration.get_configuration(timeslots, subcarriers, active_subcarriers, overlap, cp_len, cs_len)
  states: {}
- name: constel_order
  id: variable
  parameters:
    value: gfdm_constellation.bits_per_symbol()
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: subcarriers // 4
  states: {}
- name: cs_len
  id: variable
  parameters:
    value: cp_len // 2
  states: {}
- name: gfdm_constellation
  id: variable_constellation
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]'
    precision: '8'
    type: qpsk
  states: {}
- name: histogram_val
  id: variable_function_probe
  parameters:
    block_id: parser.rx_frame_formatter
    function_name: histogram_string
    poll_rate: '10'
    value: '"bla"'
  states: {state: disabled}
- name: ic_iter_range
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@1:0,0,1,1
    label: IC Iterations
    min_len: '50'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '8'
    value: '2'
  states: {}
- name: info_bytes_per_frame
  id: variable
  parameters:
    value: bytes_per_frame - 4
  states: {}
- name: latency
  id: variable_function_probe
  parameters:
    block_id: parser.rx_frame_formatter
    function_name: latency
    poll_rate: '10'
    value: '0'
  states: {state: disabled}
- name: missed_frames
  id: variable_function_probe
  parameters:
    block_id: parser.rx_frame_formatter
    function_name: missed_frames_counter
    poll_rate: '10'
    value: '0'
  states: {state: disabled}
- name: padded_frame_len
  id: variable
  parameters:
    value: conf.frame_len + 2 * padding_len
  states: {}
- name: padding_len
  id: variable
  parameters:
    value: 224 * 2
  states: {}
- name: phase_compensate
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: ctrl_tab@1:1,0,1,1
    label: compensate phase
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: ramp_len
  id: variable
  parameters:
    value: cs_len
  states: {}
- name: rgain
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:1,0,1,1
    label: RX gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '10.'
  states: {}
- name: rx_frame
  id: variable_function_probe
  parameters:
    block_id: parser
    function_name: last_frame_counter
    poll_rate: '10'
    value: '1'
  states: {state: disabled}
- name: scorr_threshold_high
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@1:5,0,1,1
    label: SCorr Threshold High
    orient: Qt.Horizontal
    start: '0.0'
    step: '.01'
    stop: '1.'
    value: '.95'
  states: {}
- name: scorr_threshold_low
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@1:4,0,1,1
    label: SCorr Threshold Low
    orient: Qt.Horizontal
    start: '0.0'
    step: '.01'
    stop: '1.'
    value: '.89'
  states: {}
- name: tfreq
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:0,0,1,1
    label: Carrier Frequency
    orient: Qt.Horizontal
    start: 2.4e9
    step: '1'
    stop: 3.8e9
    value: 2.484e9
  states: {}
- name: tgain
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:2,0,1,1
    label: TX gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '20.'
  states: {}
- name: tx_digital_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:3,0,1,1
    label: Digital Gain
    orient: Qt.Horizontal
    start: '0'
    step: '.1'
    stop: '10.'
    value: 2.7 / 2.7
  states: {}
- name: xcorr_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@1:3,0,1,1
    label: XCorr Threshold
    orient: Qt.Horizontal
    start: '0.0'
    step: '1'
    stop: '200.'
    value: '30.'
  states: {}
- name: active_subcarriers
  id: parameter
  parameters:
    label: Active subcarriers
    type: intx
    value: '52'
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '50'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_digital_gain
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: '"packet_len"'
    type: byte
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xFF'
    maxsize: info_bytes_per_frame
    minsize: info_bytes_per_frame
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: gfdm_constellation.bits_per_symbol()
    len_tag_key: '"packet_len"'
    minoutbuf: bytes_per_frame * (8 -  gfdm_constellation.bits_per_symbol())
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: gfdm_constellation.bits_per_symbol()
    l: '8'
    len_tag_key: ''
    minoutbuf: bytes_per_frame * (8 -  gfdm_constellation.bits_per_symbol())
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"rx_len"'
    packet_len: bytes_per_frame
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: '"rx_len"'
    type: byte
  states: {}
- name: configuration
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      from collections import namedtuple
      import numpy as np
      from gfdm.pygfdm import mapping
      from gfdm.pygfdm import utils
      from gfdm.pygfdm import filters
      from gfdm.pygfdm import preamble as pre_module
      from gfdm.pygfdm.gfdm_modulation import modulate_mapped_gfdm_block
      from gfdm.pygfdm.cyclic_prefix import add_cyclic_starfix, get_raised_cosine_ramp, pinch_block, get_window_len

      preamble_seed = int(3660365253)

      def get_configuration(timeslots=9, subcarriers=64, active_subcarriers=52, overlap=2, cp_len=16, cs_len=8, filtertype='rrc', filteralpha=0.2):
          ramp_len = cs_len
          dconf = {
              'timeslots': timeslots,
              'subcarriers': subcarriers,
              'active_subcarriers': active_subcarriers,
              'overlap': overlap,
              'cp_len': cp_len,
              'cs_len': cs_len,
              'ramp_len': ramp_len,
              'seed': preamble_seed,
          }
          dconf['block_len'] = block_len = timeslots * subcarriers
          dconf['window_len'] = window_len = block_len + cp_len + cs_len
          #for k, v in dconf.items():
          #    print('{:16s}:\t{}'.format(k, v))

          dconf['subcarrier_map'] = subcarrier_map = mapping.get_subcarrier_map(subcarriers, active_subcarriers, 
                                                               dc_free=True)
          preambles = pre_module.mapped_preamble(preamble_seed, filtertype, filteralpha, active_subcarriers, 
                                                 subcarriers, subcarrier_map, overlap, cp_len, ramp_len)
          dconf['full_preamble'] = full_preamble = preambles[0]
          dconf['core_preamble'] = core_preamble = preambles[1]
          dconf['preamble_len'] = preamble_len = full_preamble.size
          dconf['core_preamble_len'] = core_preamble_len = core_preamble.size
          dconf['frame_len'] = frame_len = window_len + preamble_len
          
          dconf['window_taps'] = window_taps = get_raised_cosine_ramp(ramp_len, get_window_len(cp_len, timeslots, 
                                                                                               subcarriers, cs_len))
          
          dconf['tx_filter_taps'] = tx_filter_taps = filters.get_frequency_domain_filter(filtertype, filteralpha, timeslots, subcarriers, overlap)
          dconf['rx_filter_taps'] = rx_f_taps = np.conjugate(tx_filter_taps)
          
          co = namedtuple("configuration", dconf.keys())(*dconf.values())
          return co


      def generate_payload(timeslots=9, subcarriers=64, active_subcarriers=52, overlap=2, cp_len=16, ramp_len=8):
          cs_len = ramp_len
          seed = utils.generate_seed('awesome frame')
          d = utils.get_random_qpsk(timeslots * active_subcarriers, seed)
          frame = modulate_mapped_gfdm_block(d, timeslots, subcarriers, active_subcarriers, overlap, .2, dc_free=True)
          symbol = add_cyclic_starfix(frame, cp_len, cs_len)
          window_ramp = get_raised_cosine_ramp(cs_len, get_window_len(cp_len, timeslots, subcarriers, cs_len))
          return pinch_block(symbol, window_ramp)


      def generate_preambles(subcarriers=64, active_subcarriers=52, overlap=2, cp_len=16, ramp_len=8):
          subcarrier_map = mapping.get_subcarrier_map(subcarriers, active_subcarriers, dc_free=True)
          seed = utils.generate_seed('awesome preamble')
          #print('Fancy preamble seed: ', utils.generate_seed('awesome preamble'))
          seed = int(3660365253)
          #print('static preamble seed: ', seed)
          preambles = pre_module.mapped_preamble(seed, 'rrc', .2, active_subcarriers, subcarriers, subcarrier_map, overlap, cp_len, ramp_len)
          return preambles

      preambles = generate_preambles()
      full_preamble = preambles[0]
      core_preamble = preambles[1]

      #print(full_preamble.size)
      #print(core_preamble.size)


      payload = generate_payload()

      #reference_frame = np.concatenate((full_preamble, payload))
  states: {}
- name: corr_mag_sq_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: corr_mag_squared
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: ctrl_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,4,2,2
    label0: SDR Control
    label1: DSP Control
    num_tabs: '2'
  states: {}
- name: demod_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,3,6
    label0: Demodulation
    label1: Stats
    num_tabs: '2'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    minoutbuf: timeslots * active_subcarriers
    out_type: complex
    symbol_table: gfdm_constellation.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: gfdm_constellation
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"rx_len"'
    packed: 'True'
  states: {}
- name: gfdm_short_burst_shaper_0
  id: gfdm_short_burst_shaper
  parameters:
    alias: txburstshaper
    length_tag_name: '"packet_len"'
    minoutbuf: padded_frame_len
    post_padding: padding_len
    pre_padding: padding_len
  states: {}
- name: gfdm_transmitter_cc_0
  id: gfdm_transmitter_cc
  parameters:
    active_subcarriers: active_subcarriers
    cp_len: cp_len
    cs_len: cs_len
    frequency_taps: conf.tx_filter_taps
    minoutbuf: conf.frame_len
    overlap: overlap
    per_timeslot: 'True'
    preamble: conf.full_preamble
    ramp_len: conf.ramp_len
    subcarrier_map: conf.subcarrier_map
    subcarriers: subcarriers
    timeslots: timeslots
    tsb_tag_key: '"packet_len"'
    window_taps: conf.window_taps
  states: {}
- name: hier_gfdm_fastsync_0
  id: hier_gfdm_fastsync
  parameters:
    activate_cfo_compensation: activate_cfo_compensation
    cp_len: cp_len
    frame_len: conf.frame_len
    output_tag_key: '"frame_start"'
    ref_preamble: conf.core_preamble
    sc_high_thr: scorr_threshold_high
    sc_low_thr: scorr_threshold_low
    xcorr_comp_freq: '1'
    xcorr_det_thr: xcorr_threshold
  states: {}
- name: hier_gfdm_receiver_tagged_0
  id: hier_gfdm_receiver_tagged
  parameters:
    active_subcarriers: active_subcarriers
    compensate_phase: phase_compensate
    cp_len: cp_len
    cs_len: cs_len
    frame_len: conf.frame_len
    frame_start_tag_key: '"frame_start"'
    gfdm_constellation: gfdm_constellation
    ic_iterations: ic_iter_range
    overlap: overlap
    preamble: conf.core_preamble
    ramp_len: ramp_len
    rx_filter_taps: conf.rx_filter_taps
    subcarrier_map: conf.subcarrier_map
    subcarriers: subcarriers
    timeslots: timeslots
    which_estimator: '1'
  states: {}
- name: hier_qt_live_statistics_0
  id: hier_qt_live_statistics
  parameters:
    gui_hint: 'live_stats@0: 0,0,3,7'
    histogram_val_string: histogram_val
    latency: latency
    missed_frames: missed_frames
    rx_frame: rx_frame
  states: {state: disabled}
- name: hier_qt_statistics_0
  id: hier_qt_statistics
  parameters:
    active_subcarriers: active_subcarriers
    constel_order: constel_order
    frame_len: conf.frame_len
    gui_hint: 'demod_tab@1: 2,0,3,3'
    samp_rate: samp_rate
    subcarriers: subcarriers
    timeslots: timeslots
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: live_stats
  id: qtgui_tab_widget
  parameters:
    gui_hint: demod_tab@1:0,0,2,2
    label0: Live Stats
    num_tabs: '1'
  states: {}
- name: overlap
  id: parameter
  parameters:
    label: Overlap
    type: intx
    value: '2'
  states: {}
- name: qtgui_const_sink_rx_symbols
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    color1: '"green"'
    grid: 'True'
    gui_hint: 'demod_tab@0: 0,0,2,2'
    legend: 'False'
    name: '"RX Constellation"'
    size: timeslots * active_subcarriers
    type: complex
    update_time: '0.30'
  states: {}
- name: qtgui_time_sink_channel_estimate
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    axislabels: 'False'
    gui_hint: 'demod_tab@0: 0, 2, 1, 2'
    label1: Re{estimate}
    label2: Im{estimate}
    name: '"Channel Estimate"'
    size: conf.block_len
    srate: samp_rate * 0 + 1
    tr_level: '0.05'
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.1'
    width1: '4'
    width2: '4'
  states: {state: disabled}
- name: qtgui_time_sink_channel_estimate_0
  id: qtgui_time_sink_x
  parameters:
    axislabels: 'False'
    grid: 'True'
    gui_hint: 'demod_tab@0: 0, 2, 1, 2'
    label1: magnitude
    label2: phase
    name: '"Channel Estimate"'
    nconnections: '2'
    size: conf.block_len
    srate: samp_rate * 0 + 1
    tr_level: '0.05'
    tr_tag: '"frame_start"'
    type: float
    update_time: '0.1'
    width1: '4'
    width2: '4'
    ymax: '3.2'
    ymin: '-3.2'
  states: {}
- name: qtgui_time_sink_detected_frames
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'sync_tab@0: 2, 0, 1,1'
    label1: ''
    label2: ''
    legend: 'False'
    name: '"detected frames"'
    size: conf.frame_len * 3
    srate: samp_rate
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_synced_stream
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 'sync_tab@0: 0, 0, 1,1'
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    legend: 'False'
    name: '"synchronization"'
    nconnections: '2'
    size: int(samp_rate / 500)
    srate: samp_rate
    tr_delay: '30e-6'
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.2'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: 12.5e6
  states: {}
- name: subcarriers
  id: parameter
  parameters:
    label: Subcarriers
    type: intx
    value: '64'
  states: {}
- name: sync_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,4,4
    label0: Synchronization
    num_tabs: '1'
  states: {}
- name: timeslots
  id: parameter
  parameters:
    label: Timeslots
    type: intx
    value: '9'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tfreq
    clock_rate: '0.0'
    dev_addr: '"addr=134.102.176.209"'
    dev_args: '""'
    gain0: tgain
    len_tag_name: '"packet_len"'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: tfreq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: '"addr=134.102.176.211"'
    dev_args: '""'
    gain0: rgain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', qtgui_time_sink_channel_estimate_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_channel_estimate_0, '1']
- [blocks_message_strobe_0_0, strobe, blocks_random_pdu_0, generate]
- [blocks_multiply_const_vxx_0, '0', gfdm_short_burst_shaper_0, '0']
- [blocks_pdu_to_tagged_stream_0_1, '0', digital_crc32_bb_0, '0']
- [blocks_random_pdu_0, pdus, blocks_pdu_to_tagged_stream_0_1, pdus]
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0_0, print_pdu]
- [corr_mag_sq_complex, '0', qtgui_time_sink_synced_stream, '1']
- [corr_mag_squared, '0', corr_mag_sq_complex, '0']
- [digital_chunks_to_symbols_xx_0, '0', gfdm_transmitter_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_crc32_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [gfdm_short_burst_shaper_0, '0', uhd_usrp_sink_0, '0']
- [gfdm_transmitter_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [hier_gfdm_fastsync_0, '0', hier_gfdm_receiver_tagged_0, '0']
- [hier_gfdm_fastsync_0, '0', qtgui_time_sink_detected_frames, '0']
- [hier_gfdm_fastsync_0, '1', qtgui_time_sink_synced_stream, '0']
- [hier_gfdm_fastsync_0, '2', corr_mag_squared, '0']
- [hier_gfdm_receiver_tagged_0, '0', blocks_complex_to_magphase_0, '0']
- [hier_gfdm_receiver_tagged_0, '0', qtgui_time_sink_channel_estimate, '0']
- [hier_gfdm_receiver_tagged_0, '1', digital_constellation_decoder_cb_0, '0']
- [hier_gfdm_receiver_tagged_0, '1', qtgui_const_sink_rx_symbols, '0']
- [uhd_usrp_source_0, '0', hier_gfdm_fastsync_0, '0']

metadata:
  file_format: 1
