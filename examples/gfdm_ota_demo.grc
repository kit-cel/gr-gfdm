options:
  parameters:
    author: Johannes Demel
    generate_options: qt_gui
    id: gfdm_ota_demo
    output_language: python
    title: GFDM over-the-air Demo
  states: {}

blocks:
- name: active_subcarriers
  id: variable
  parameters:
    value: '52'
  states: {}
- name: active_symbols
  id: variable_qtgui_label
  parameters:
    gui_hint: 'demod_tab@1: 0,1,1,1'
    label: Active Symbols
    type: int
    value: timeslots * active_subcarriers
  states: {}
- name: bits_per_frame
  id: variable_qtgui_label
  parameters:
    gui_hint: 'demod_tab@1: 0,2,1,1'
    label: Num bits
    type: int
    value: int(np.log2(len(gfdm_constellation.points() ) )) * active_symbols
  states: {}
- name: block_len
  id: variable
  parameters:
    value: timeslots * fft_len
  states: {}
- name: bytes_per_frame
  id: variable
  parameters:
    value: int(bits_per_frame // 8)
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: fft_len // 2
  states: {}
- name: cs_len
  id: variable
  parameters:
    value: cp_len // 2
  states: {}
- name: data_rate
  id: variable_qtgui_label
  parameters:
    gui_hint: 'demod_tab@1: 0,3,1,1'
    label: Data Rate
    type: int
    value: int(1000. * bits_per_frame)
  states: {}
- name: f_taps
  id: variable
  parameters:
    value: filters.get_frequency_domain_filter('rrc', .2, timeslots, fft_len, overlap)
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_dur
  id: variable_qtgui_label
  parameters:
    gui_hint: 'demod_tab@1: 1,0,1,1'
    label: Frame Duration
    type: real
    value: 1. * frame_len / samp_rate
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: window_len + len(preamble)
  states: {}
- name: gfdm_constellation
  id: variable_constellation
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]'
    precision: '8'
    type: qpsk
  states: {}
- name: ic_iter_range
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,3,1,1
    label: IC Iterations
    min_len: '50'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '256'
    value: '2'
  states: {}
- name: modulated_preambles
  id: variable
  parameters:
    value: pre_module.mapped_preamble(seed, 'rrc', .2, active_subcarriers, fft_len, subcarrier_map, overlap, cp_len, ramp_len)
  states: {}
- name: overlap
  id: variable
  parameters:
    value: '2'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: modulated_preambles[0]
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: len(preamble)
  states: {}
- name: ramp_len
  id: variable
  parameters:
    value: cs_len
  states: {}
- name: rgain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '40.'
  states: {}
- name: rx_f_taps
  id: variable
  parameters:
    value: np.conjugate(f_taps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3.125e6 * 1
  states: {}
- name: seed
  id: variable
  parameters:
    value: utils.generate_seed('awesome preamble')
  states: {}
- name: subcarrier_map
  id: variable
  parameters:
    value: mapping.get_subcarrier_map(fft_len, active_subcarriers, dc_free=True)
  states: {}
- name: tfreq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 2.46e9
    step: '1'
    stop: 2.490e9
    value: 2.4805e9
  states: {}
- name: tgain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '20.'
  states: {}
- name: timeslots
  id: variable
  parameters:
    value: '5'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 'demod_tab@1: 0,0,1,1'
    label: Block length
    type: int
    value: block_len
  states: {}
- name: window_len
  id: variable
  parameters:
    value: block_len + cp_len + cs_len
  states: {}
- name: window_taps
  id: variable
  parameters:
    value: cyclic_prefix.get_raised_cosine_ramp(ramp_len, cyclic_prefix.get_window_len(cp_len, timeslots, fft_len, cs_len))
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.0'
    type: complex
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xFF'
    maxsize: bytes_per_frame - 20
    minsize: bytes_per_frame - 20
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: gfdm_constellation.bits_per_symbol()
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: gfdm_constellation.bits_per_symbol()
    l: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"rx_len"'
    packet_len: bytes_per_frame
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: frame_len
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: rx_len
    type: byte
  states: {}
- name: demod_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,3,4
    label0: Demodulation
    label1: Stats
    num_tabs: '2'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: gfdm_constellation.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: gfdm_constellation.base()
  states: {}
- name: digital_crc32_async_bb_1_0
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
  states: {}
- name: gfdm_transmitter_cc_0
  id: gfdm_transmitter_cc
  parameters:
    active_subcarriers: active_subcarriers
    cp_len: cp_len
    cs_len: cs_len
    frequency_taps: f_taps
    overlap: overlap
    per_timeslot: 'True'
    preamble: preamble
    ramp_len: ramp_len
    subcarrier_map: subcarrier_map
    subcarriers: fft_len
    timeslots: timeslots
    tsb_tag_key: '"packet_len"'
    window_taps: window_taps
  states: {}
- name: hier_gfdm_fastsync_0
  id: hier_gfdm_fastsync
  parameters:
    activate_cfo_compensation: 'False'
    cp_len: cp_len
    frame_len: frame_len
    output_tag_key: '"frame_start"'
    ref_preamble: modulated_preambles[1]
    sc_high_thr: '.7'
    sc_low_thr: '.6'
    xcorr_comp_freq: 'False'
    xcorr_det_thr: '10.'
  states: {}
- name: hier_gfdm_receiver_tagged_0
  id: hier_gfdm_receiver_tagged
  parameters:
    active_subcarriers: active_subcarriers
    compensate_phase: '0'
    cp_len: cp_len
    frame_len: frame_len
    frame_start_tag_key: '"frame_start"'
    gfdm_constellation: gfdm_constellation
    ic_iterations: ic_iter_range
    overlap: overlap
    ramp_len: ramp_len
    rx_filter_taps: rx_f_taps
    subcarrier_map: subcarrier_map
    subcarriers: fft_len
    timeslots: timeslots
    which_estimator: '0'
  states: {}
- name: hier_packet_formatter_0
  id: hier_packet_formatter
  parameters:
    dst_id: '84'
    length_tag_name: '"packet_len"'
    src_id: '42'
  states: {}
- name: import_cyclic_prefix
  id: import
  parameters:
    imports: from gfdm.pygfdm import cyclic_prefix
  states: {}
- name: import_cyclic_prefix_0
  id: import
  parameters:
    imports: from gfdm.pygfdm import utils
  states: {}
- name: import_filters
  id: import
  parameters:
    imports: from gfdm.pygfdm import filters
  states: {}
- name: import_mapping
  id: import
  parameters:
    imports: from gfdm.pygfdm import mapping
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_synchronization
  id: import
  parameters:
    imports: from gfdm.pygfdm import preamble as pre_module
  states: {}
- name: import_validation
  id: import
  parameters:
    imports: from gfdm.pygfdm import validation_utils as vu
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"green"'
    grid: 'True'
    gui_hint: 'demod_tab@0: 0,0,3,3'
    legend: 'False'
    name: '"RX Constellation"'
    size: timeslots * active_subcarriers
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'sync_tab@0: 0, 0, 1,1'
    label1: ''
    label2: ''
    legend: 'False'
    name: '"Energy-detected bursts"'
    size: frame_len * 12
    srate: samp_rate
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'sync_tab@0: 1, 0, 1,1'
    label1: ''
    label2: ''
    legend: 'False'
    name: '"Frame-synchronized bursts"'
    size: frame_len * 12
    srate: samp_rate
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'demod_tab@0: 0, 3, 1,1'
    label1: Re{estimate}
    label2: Im{estimate}
    name: '"Channel Estimate"'
    size: block_len
    srate: samp_rate * 0 + 1
    tr_level: '0.05'
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.1'
    width1: '4'
    width2: '4'
  states: {}
- name: qtgui_time_sink_x_0_0_0_2_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'sync_tab@0: 2, 0, 1,1'
    label1: ''
    legend: 'False'
    name: '"bits"'
    size: bytes_per_frame * 4
    srate: samp_rate
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: rx_len
    type: float
    update_time: '0.1'
    ylabel: value
    ymax: '160'
    ymin: '-160'
  states: {}
- name: rx_frame_formatter
  id: polarwrap_frame_formatter
  parameters:
    tx_mode: 'False'
  states: {}
- name: sync_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,4,4
    label0: Synchronization
    num_tabs: '1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tfreq
    clock_rate: '0.0'
    clock_source0: external
    dev_addr: '"addr=134.102.176.200"'
    dev_args: '""'
    gain0: tgain
    len_tag_name: '"packet_len"'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: tfreq
    clock_rate: '0.0'
    clock_source0: external
    dc_offs_enb0: '""'
    dev_addr: '"addr=134.102.176.201"'
    dev_args: '""'
    gain0: rgain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0_0_2_0_1, '0']
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_random_pdu_0, pdus, hier_packet_formatter_0, in]
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', uhd_usrp_sink_0, '0']
- [blocks_tag_gate_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, digital_crc32_async_bb_1_0, in]
- [digital_chunks_to_symbols_xx_0, '0', gfdm_transmitter_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_crc32_async_bb_1_0, out, blocks_message_debug_0, print_pdu]
- [digital_crc32_async_bb_1_0, out, rx_frame_formatter, PDUin]
- [gfdm_transmitter_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [hier_gfdm_fastsync_0, '0', hier_gfdm_receiver_tagged_0, '0']
- [hier_gfdm_fastsync_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [hier_gfdm_fastsync_0, '1', qtgui_time_sink_x_0_0_0, '0']
- [hier_gfdm_receiver_tagged_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [hier_gfdm_receiver_tagged_0, '1', digital_constellation_decoder_cb_0, '0']
- [hier_gfdm_receiver_tagged_0, '1', qtgui_const_sink_x_0, '0']
- [hier_packet_formatter_0, '0', blocks_tag_gate_0, '0']
- [rx_frame_formatter, frame, blocks_message_debug_0, print_pdu]
- [uhd_usrp_source_0, '0', hier_gfdm_fastsync_0, '0']

metadata:
  file_format: 1
