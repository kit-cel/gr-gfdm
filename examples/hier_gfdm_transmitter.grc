options:
  parameters:
    author: Johannes Demel
    category: '[GFDM]'
    generate_options: hb
    id: hier_gfdm_transmitter
    output_language: python
    title: GFDM Transmitter chain
  states: {}

blocks:
- name: block_len
  id: variable
  parameters:
    value: timeslots * subcarriers
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: window_len + preamble_len
  states: {}
- name: preamble_gap
  id: variable
  parameters:
    value: '256'
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: len(preamble)
  states: {}
- name: window_len
  id: variable
  parameters:
    value: block_len + cp_len + cs_len
  states: {}
- name: active_subcarriers
  id: parameter
  parameters:
    type: intx
    value: '52'
  states: {}
- name: cp_len
  id: parameter
  parameters:
    type: intx
    value: '32'
  states: {}
- name: cs_len
  id: parameter
  parameters:
    type: intx
    value: '16'
  states: {}
- name: filter_taps
  id: parameter
  parameters:
    value: filters.get_frequency_domain_filter('rrc', .2, 9, 64, 2)
  states: {}
- name: gfdm_cyclic_prefixer_cc_0
  id: gfdm_cyclic_prefixer_cc
  parameters:
    block_len: block_len
    cp_length: cp_len
    cs_length: cs_len
    ramp_len: ramp_len
    window_taps: window_taps
  states: {}
- name: gfdm_resource_mapper_cc_0
  id: gfdm_resource_mapper_cc
  parameters:
    active_subcarriers: active_subcarriers
    per_timeslot: 'True'
    subcarrier_map: subcarrier_map
    subcarriers: subcarriers
    timeslots: timeslots
  states: {}
- name: gfdm_simple_modulator_cc_0
  id: gfdm_simple_modulator_cc
  parameters:
    frequency_taps: filter_taps
    n_subcarriers: subcarriers
    n_timeslots: timeslots
    overlap: overlap
  states: {}
- name: import_cyclic_prefix
  id: import
  parameters:
    imports: from gfdm.pygfdm import cyclic_prefix
  states: {}
- name: import_filters
  id: import
  parameters:
    imports: from gfdm.pygfdm import filters
  states: {}
- name: import_mapping
  id: import
  parameters:
    imports: from gfdm.pygfdm import mapping
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_synchronization
  id: import
  parameters:
    imports: from gfdm.pygfdm import preamble as pre_module
  states: {}
- name: overlap
  id: parameter
  parameters:
    type: intx
    value: '2'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: preamble
  id: parameter
  parameters:
    value: pre_module.mapped_preamble(471142, 'rrc', .2, 52, 64, mapping.get_subcarrier_map(64, 52, dc_free=True), 2, 32, 16)[0]
  states: {}
- name: preamble_vector_insert
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: frame_len
    type: complex
    vector: preamble
  states: {}
- name: preamble_vector_insert_0
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: window_len + preamble_gap
    type: complex
    vector: np.zeros(preamble_gap)
  states: {state: bypassed}
- name: ramp_len
  id: parameter
  parameters:
    type: intx
    value: '16'
  states: {}
- name: subcarrier_map
  id: parameter
  parameters:
    value: mapping.get_subcarrier_map(64, 52, dc_free=True)
  states: {}
- name: subcarriers
  id: parameter
  parameters:
    type: intx
    value: '64'
  states: {}
- name: timeslots
  id: parameter
  parameters:
    type: intx
    value: '9'
  states: {}
- name: window_taps
  id: parameter
  parameters:
    value: cyclic_prefix.get_root_raised_cosine_ramp(16, 624)
  states: {}

connections:
- [gfdm_cyclic_prefixer_cc_0, '0', preamble_vector_insert_0, '0']
- [gfdm_resource_mapper_cc_0, '0', gfdm_simple_modulator_cc_0, '0']
- [gfdm_simple_modulator_cc_0, '0', gfdm_cyclic_prefixer_cc_0, '0']
- [pad_source_0, '0', gfdm_resource_mapper_cc_0, '0']
- [preamble_vector_insert, '0', pad_sink_0, '0']
- [preamble_vector_insert_0, '0', preamble_vector_insert, '0']

metadata:
  file_format: 1
