<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hier_gfdm_transmitter</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>[GFDM]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>GFDM Transmitter chain</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block_len</value></param>
<param><key>value</key><value>timeslots * subcarriers</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>value</key><value>window_len + preamble_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_gap</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>value</key><value>len(preamble)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_len</value></param>
<param><key>value</key><value>block_len + cp_len + cs_len</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>active_subcarriers</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>52</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cs_len</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filter_taps</value></param>
<param><key>value</key><value>filters.get_frequency_domain_filter('rrc', .2, 9, 64, 2)</value></param>
</block>
<block>
<key>gfdm_cyclic_prefixer_cc</key>
<param><key>id</key><value>gfdm_cyclic_prefixer_cc_0</value></param>
<param><key>block_len</key><value>block_len</value></param>
<param><key>cp_length</key><value>cp_len</value></param>
<param><key>cs_length</key><value>cs_len</value></param>
<param><key>ramp_len</key><value>ramp_len</value></param>
<param><key>window_taps</key><value>window_taps</value></param>
</block>
<block>
<key>gfdm_resource_mapper_cc</key>
<param><key>id</key><value>gfdm_resource_mapper_cc_0</value></param>
<param><key>active_subcarriers</key><value>active_subcarriers</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>per_timeslot</key><value>True</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
</block>
<block>
<key>gfdm_simple_modulator_cc</key>
<param><key>id</key><value>gfdm_simple_modulator_cc_0</value></param>
<param><key>frequency_taps</key><value>filter_taps</value></param>
<param><key>n_subcarriers</key><value>subcarriers</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>n_timeslots</key><value>timeslots</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_cyclic_prefix</value></param>
<param><key>import</key><value>from gfdm.pygfdm import cyclic_prefix</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_filters</value></param>
<param><key>import</key><value>from gfdm.pygfdm import filters</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_mapping</value></param>
<param><key>import</key><value>from gfdm.pygfdm import mapping</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_numpy</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_synchronization</value></param>
<param><key>import</key><value>from gfdm.pygfdm import preamble as pre_module</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>overlap</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>pre_module.mapped_preamble(471142, 'rrc', .2, 52, 64, mapping.get_subcarrier_map(64, 52, dc_free=True), 2, 32, 16)[0]</value></param>
</block>
<block>
<key>blocks_vector_insert_x</key>
<param><key>id</key><value>preamble_vector_insert</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>period</key><value>frame_len + preamble_gap</value></param>
<param><key>vector</key><value>preamble</value></param>
</block>
<block>
<key>blocks_vector_insert_x</key>
<param><key>id</key><value>preamble_vector_insert_0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>period</key><value>window_len + preamble_gap</value></param>
<param><key>vector</key><value>np.zeros(preamble_gap)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ramp_len</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarrier_map</value></param>
<param><key>value</key><value>mapping.get_subcarrier_map(64, 52, dc_free=True)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>timeslots</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>window_taps</value></param>
<param><key>value</key><value>cyclic_prefix.get_root_raised_cosine_ramp(16, 624)</value></param>
</block>
<connection><source_block_id>gfdm_cyclic_prefixer_cc_0</source_block_id><sink_block_id>preamble_vector_insert_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_resource_mapper_cc_0</source_block_id><sink_block_id>gfdm_simple_modulator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_modulator_cc_0</source_block_id><sink_block_id>gfdm_cyclic_prefixer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>gfdm_resource_mapper_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>preamble_vector_insert</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>preamble_vector_insert_0</source_block_id><sink_block_id>preamble_vector_insert</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
