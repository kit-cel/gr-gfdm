<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gfdm_transceiver_test</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>send and receive GFDM frames</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>qt_qss_theme</key><value>/home/demel/src/dark_custom.qss</value></param>
<param><key>title</key><value>GFDM Transceiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>active_subcarriers</value></param>
<param><key>value</key><value>110</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>attenuation</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>gui_hint</key><value>7,8,1,1</value></param>
<param><key>label</key><value>Attenuation</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>2.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>backoff_len</value></param>
<param><key>value</key><value>80</value></param>
<param><key>gui_hint</key><value>3,8,1,1</value></param>
<param><key>label</key><value>TDD Backoff</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1024</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block_len</value></param>
<param><key>value</key><value>timeslots * fft_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>complex_info_symbols_per_frame</value></param>
<param><key>value</key><value>timeslots * active_subcarriers</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cs_len</value></param>
<param><key>value</key><value>ramp_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_taps</value></param>
<param><key>value</key><value>filters.get_frequency_domain_filter('rrc', .5, timeslots, fft_len, overlap)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_duration</value></param>
<param><key>value</key><value>frame_len / samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_gap</value></param>
<param><key>value</key><value>np.zeros(frame_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>value</key><value>window_len + len(preamble)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>gui_hint</key><value>6,8,1,1</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100e3</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100e3</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>gfdm_constellation</value></param>
<param><key>const_points</key><value>[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ic_iter_range</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>5,8,1,1</value></param>
<param><key>label</key><value>IC Iterations</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>256</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_preambles</value></param>
<param><key>value</key><value>pre_module.mapped_preamble(seed, 'rrc', .5, active_subcarriers, fft_len, subcarrier_map, overlap, cp_len, ramp_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>overlap</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>phase_increment</value></param>
<param><key>value</key><value>2 * np.pi * freq_offset / samp_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>5,0,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>modulated_preambles[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>value</key><value>len(preamble)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ramp_len</value></param>
<param><key>value</key><value>cp_len // 4</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>relative_cfo</value></param>
<param><key>value</key><value>freq_offset / subcarrier_bw</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>4,0,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_f_taps</value></param>
<param><key>value</key><value>numpy.conjugate(f_taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>usrp_rate / 8.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>seed</value></param>
<param><key>value</key><value>abs(hash('awesome')) % (2**32)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subcarrier_bw</value></param>
<param><key>value</key><value>samp_rate / fft_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subcarrier_map</value></param>
<param><key>value</key><value>np.concatenate((np.arange(active_subcarriers // 2), np.arange(fft_len - active_subcarriers // 2, fft_len)))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tdd_alpha</value></param>
<param><key>value</key><value>20.</value></param>
<param><key>gui_hint</key><value>4,8,1,1</value></param>
<param><key>label</key><value>TDD alpha</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeslots</value></param>
<param><key>value</key><value>9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>used_bw</value></param>
<param><key>value</key><value>subcarrier_bw * active_subcarriers</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_rate</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_len</value></param>
<param><key>value</key><value>block_len + cp_len + cs_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_taps</value></param>
<param><key>value</key><value>cyclic_prefix.get_root_raised_cosine_ramp(ramp_len, window_len)</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>len(gfdm_constellation.points())</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>timeslots * active_subcarriers * 50</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>freq_offset</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor</key>
<param><key>id</key><value>blocks_ctrlport_monitor_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>attenuation</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>complex_tx_symbols</value></param>
<param><key>stream_id</key><value>tx_syms</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>complex_tx_symbols_0</value></param>
<param><key>stream_id</key><value>rx_syms</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>complex_tx_symbols_1</value></param>
<param><key>stream_id</key><value>rx_frames</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>complex_tx_symbols_2</value></param>
<param><key>stream_id</key><value>tx_frames</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>gfdm_constellation.points()</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>gfdm_constellation</value></param>
</block>
<block>
<key>blocks_vector_insert_x</key>
<param><key>id</key><value>frame_gap_vector_insert</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>period</key><value>frame_len + len(frame_gap)</value></param>
<param><key>vector</key><value>frame_gap</value></param>
</block>
<block>
<key>gfdm_frame_energy_detector_cc</key>
<param><key>id</key><value>gfdm_frame_energy_detector_cc_0</value></param>
<param><key>alpha</key><value>tdd_alpha</value></param>
<param><key>average_len</key><value>48</value></param>
<param><key>backoff_len</key><value>backoff_len</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>tag_key</key><value>energy_start</value></param>
</block>
<block>
<key>gfdm_simple_preamble_sync_cc</key>
<param><key>id</key><value>gfdm_simple_preamble_sync_cc_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>in_key</key><value>energy_start</value></param>
<param><key>out_key</key><value>frame_start</value></param>
<param><key>preamble</key><value>modulated_preambles[1]</value></param>
<param><key>subcarriers</key><value>fft_len</value></param>
</block>
<block>
<key>hier_gfdm_receiver</key>
<param><key>id</key><value>hier_gfdm_receiver_0</value></param>
<param><key>active_subcarriers</key><value>active_subcarriers</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>frame_start_tag_key</key><value>"frame_start"</value></param>
<param><key>gfdm_constellation</key><value>gfdm_constellation</value></param>
<param><key>ic_iterations</key><value>ic_iter_range</value></param>
<param><key>offset</key><value> len(preamble) + cp_len</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>rx_filter_taps</key><value>rx_f_taps</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
<param><key>subcarriers</key><value>fft_len</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
</block>
<block>
<key>hier_gfdm_transmitter</key>
<param><key>id</key><value>hier_gfdm_transmitter_0</value></param>
<param><key>active_subcarriers</key><value>active_subcarriers</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>cs_len</key><value>cs_len</value></param>
<param><key>filter_taps</key><value>f_taps</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>preamble</key><value>preamble</value></param>
<param><key>ramp_len</key><value>ramp_len</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
<param><key>subcarriers</key><value>fft_len</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
<param><key>window_taps</key><value>window_taps</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_cyclic_prefix</value></param>
<param><key>import</key><value>from gfdm.pygfdm import cyclic_prefix</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_filters</value></param>
<param><key>import</key><value>from gfdm.pygfdm import filters</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_numpy</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_synchronization</value></param>
<param><key>import</key><value>from gfdm.pygfdm import preamble as pre_module</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>3,3,3,3</value></param>
<param><key>label1</key><value>TX</value></param>
<param><key>label2</key><value>RX</value></param>
<param><key>name</key><value>"Constellation symbols"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>timeslots * fft_len</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_rx</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,0,3,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"RX time signal"</value></param>
<param><key>size</key><value>1 * frame_len</value></param>
<param><key>srate</key><value>1.</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"frame_start"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>1. </value></param>
<param><key>ymin</key><value>-1. </value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>0,0,1,9</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Re{TX}</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Im{TX}</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Re{RX}</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>Im{RX}</value></param>
<param><key>name</key><value>"TX and RX frames"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1 * frame_len</value></param>
<param><key>srate</key><value>1.</value></param>
<param><key>tr_chan</key><value>2</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"frame_start"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>1. </value></param>
<param><key>ymin</key><value>-1. </value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,1,9</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Re{TX}</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Im{TX}</value></param>
<param><key>name</key><value>"TX and RX frames"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1 * frame_len</value></param>
<param><key>srate</key><value>1.</value></param>
<param><key>tr_tag</key><value>"frame_start"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1. </value></param>
<param><key>ymin</key><value>-1. </value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_ota</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0.0</value></param>
<param><key>fftsize</key><value>fft_len</value></param>
<param><key>gui_hint</key><value>3,0,3,3</value></param>
<param><key>name</key><value>"over-the-air waterfall"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>tx_syms_src</value></param>
<param><key>stream_id</key><value>tx_syms</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>tx_syms_src_0</value></param>
<param><key>stream_id</key><value>rx_syms</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>tx_syms_src_0_0</value></param>
<param><key>stream_id</key><value>rx_frames</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>tx_syms_src_1</value></param>
<param><key>stream_id</key><value>tx_frames</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>gfdm_frame_energy_detector_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_ota</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>complex_tx_symbols</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>hier_gfdm_transmitter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frame_gap_vector_insert</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_frame_energy_detector_cc_0</source_block_id><sink_block_id>gfdm_simple_preamble_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>complex_tx_symbols_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>hier_gfdm_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>qtgui_time_sink_rx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_gfdm_receiver_0</source_block_id><sink_block_id>complex_tx_symbols_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_gfdm_receiver_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_gfdm_transmitter_0</source_block_id><sink_block_id>complex_tx_symbols_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_gfdm_transmitter_0</source_block_id><sink_block_id>frame_gap_vector_insert</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tx_syms_src</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tx_syms_src_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>tx_syms_src_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>tx_syms_src_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
