<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hier_gfdm_receiver</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>[GFDM]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>GFDM Receiver chain</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block_len</value></param>
<param><key>value</key><value>timeslots * subcarriers</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>active_subcarriers</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>110</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>800</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_start_tag_key</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>frame_start</value></param>
</block>
<block>
<key>gfdm_advanced_receiver_sb_cc</key>
<param><key>id</key><value>gfdm_advanced_receiver_sb_cc_0</value></param>
<param><key>constellation</key><value>gfdm_constellation</value></param>
<param><key>frequency_taps</key><value>rx_filter_taps</value></param>
<param><key>ic_iter</key><value>ic_iterations</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gfdm_constellation</value></param>
<param><key>value</key><value>digital.constellation_qpsk().base()</value></param>
</block>
<block>
<key>gfdm_remove_prefix_cc</key>
<param><key>id</key><value>gfdm_remove_prefix_cc_0</value></param>
<param><key>block_len</key><value>timeslots * subcarriers</value></param>
<param><key>frame_len</key><value>frame_len</value></param>
<param><key>offset</key><value>offset</value></param>
<param><key>gfdm_sync_tag_key</key><value>frame_start_tag_key</value></param>
</block>
<block>
<key>gfdm_resource_demapper_cc</key>
<param><key>id</key><value>gfdm_resource_demapper_cc_0</value></param>
<param><key>active_subcarriers</key><value>active_subcarriers</value></param>
<param><key>subcarriers</key><value>subcarriers</value></param>
<param><key>per_timeslot</key><value>True</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
<param><key>timeslots</key><value>timeslots</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ic_iterations</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_digital</value></param>
<param><key>import</key><value>from gnuradio import digital</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_numpy</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>offset</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>160</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>overlap</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_filter_taps</value></param>
<param><key>value</key><value>np.ones(10)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarrier_map</value></param>
<param><key>value</key><value>np.arange(110)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>timeslots</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5</value></param>
</block>
<connection><source_block_id>gfdm_advanced_receiver_sb_cc_0</source_block_id><sink_block_id>gfdm_resource_demapper_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_remove_prefix_cc_0</source_block_id><sink_block_id>gfdm_advanced_receiver_sb_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_resource_demapper_cc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>gfdm_remove_prefix_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
