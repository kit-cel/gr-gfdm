<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hier_packet_formatter</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>[GFDM]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Packet Formatter</value></param>
</block>
<block>
<key>blocks_pdu_set</key>
<param><key>id</key><value>blocks_pdu_set_0</value></param>
<param><key>k</key><value>pmt.intern("dst_id")</value></param>
<param><key>v</key><value>pmt.from_long(dst_id)</value></param>
</block>
<block>
<key>blocks_pdu_set</key>
<param><key>id</key><value>blocks_pdu_set_0_0</value></param>
<param><key>k</key><value>pmt.intern("src_id")</value></param>
<param><key>v</key><value>pmt.from_long(src_id)</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>length_tag_name</value></param>
</block>
<block>
<key>crypto_frame_formatter</key>
<param><key>id</key><value>crypto_frame_formatter_0</value></param>
<param><key>tx_mode</key><value>True</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_1_0</value></param>
<param><key>check</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dst_id</value></param>
<param><key>label</key><value>Destination ID</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>84</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>length_tag_name</value></param>
<param><key>label</key><value>Length tag name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>packet_len</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1_0_0_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>pdu</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>src_id</value></param>
<param><key>label</key><value>Source ID</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>42</value></param>
</block>
<connection><source_block_id>blocks_pdu_set_0</source_block_id><sink_block_id>blocks_pdu_set_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_pdu_set_0_0</source_block_id><sink_block_id>crypto_frame_formatter_0</sink_block_id><source_key>pdus</source_key><sink_key>PDUin</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1</source_block_id><sink_block_id>pad_sink_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crypto_frame_formatter_0</source_block_id><sink_block_id>digital_crc32_async_bb_1_0</sink_block_id><source_key>frame</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1_0</source_block_id><sink_block_id>pad_sink_1_0_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_pdu_set_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
