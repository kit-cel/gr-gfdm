<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gfdm_file_sync</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>burst_backoff</value></param>
<param><key>value</key><value>look_ahead_val</value></param>
<param><key>gui_hint</key><value>0, 3,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>8 * look_ahead_val</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_taps</value></param>
<param><key>value</key><value>filters.get_frequency_domain_filter('rrc', .2, 9, 64, 2)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>gui_hint</key><value>2,3,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10.e3</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10e3</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>gfdm_constellation</value></param>
<param><key>const_points</key><value>[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ic_iter_range</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>label</key><value>IC Iterations</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>256</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>look_ahead_val</value></param>
<param><key>value</key><value>cp_len * 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>modulated_preambles</value></param>
<param><key>value</key><value>pre_module.mapped_preamble(seed, 'rrc', .2, 52, 64, subcarrier_map, 2, cp_len, cp_len // 2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_f_taps</value></param>
<param><key>value</key><value>np.conjugate(f_taps)</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>rx_lp_taps</value></param>
<param><key>cutoff_freq</key><value>1.4e6</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>400e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_preamble</value></param>
<param><key>value</key><value>signal.resample(modulated_preambles[1], 4 * len(modulated_preambles[1]))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>12.5e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>seed</value></param>
<param><key>value</key><value>utils.generate_seed('awesome preamble')</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subcarrier_map</value></param>
<param><key>value</key><value>mapping.get_subcarrier_map(64, 52, dc_free=True)</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor_performance</key>
<param><key>id</key><value>blocks_ctrlport_monitor_performance_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/demel/iq_samples/gfdm_50ms_slice.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/lhome/records/gfdm_gr_fg_synced_frames.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/lhome/records/gfdm_replay_ref_frame_synced.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>int(samp_rate / 20)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>int(samp_rate * 10)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>freq_offset</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>rx_lp_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>gfdm_advanced_receiver_sb_cc</key>
<param><key>id</key><value>gfdm_advanced_receiver_sb_cc_0</value></param>
<param><key>constellation</key><value>gfdm_constellation</value></param>
<param><key>frequency_taps</key><value>rx_f_taps</value></param>
<param><key>ic_iter</key><value>ic_iter_range</value></param>
<param><key>overlap</key><value>2</value></param>
<param><key>timeslots</key><value>9</value></param>
<param><key>subcarriers</key><value>64</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
</block>
<block>
<key>gfdm_channel_estimator_cc</key>
<param><key>id</key><value>gfdm_channel_estimator_cc_0</value></param>
<param><key>active_subcarriers</key><value>52</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>preamble</key><value>modulated_preambles[1]</value></param>
<param><key>timeslots</key><value>9</value></param>
<param><key>is_dc_free</key><value>True</value></param>
</block>
<block>
<key>gfdm_extract_burst_cc</key>
<param><key>id</key><value>gfdm_extract_burst_cc_0</value></param>
<param><key>burst_start_tag</key><value>'energy_start'</value></param>
<param><key>burst_len</key><value>1000</value></param>
</block>
<block>
<key>gfdm_remove_prefix_cc</key>
<param><key>id</key><value>gfdm_remove_prefix_cc_0</value></param>
<param><key>block_len</key><value>64 * 2</value></param>
<param><key>frame_len</key><value>800</value></param>
<param><key>offset</key><value>32</value></param>
<param><key>gfdm_sync_tag_key</key><value>frame_start</value></param>
</block>
<block>
<key>gfdm_remove_prefix_cc</key>
<param><key>id</key><value>gfdm_remove_prefix_cc_0_0</value></param>
<param><key>block_len</key><value>64 * 9</value></param>
<param><key>frame_len</key><value>800</value></param>
<param><key>offset</key><value>32 + 64 * 2 + 16 + 32</value></param>
<param><key>gfdm_sync_tag_key</key><value>frame_start</value></param>
</block>
<block>
<key>gfdm_resource_demapper_cc</key>
<param><key>id</key><value>gfdm_resource_demapper_cc_0</value></param>
<param><key>active_subcarriers</key><value>52</value></param>
<param><key>subcarriers</key><value>64</value></param>
<param><key>per_timeslot</key><value>True</value></param>
<param><key>subcarrier_map</key><value>subcarrier_map</value></param>
<param><key>timeslots</key><value>9</value></param>
</block>
<block>
<key>gfdm_simple_preamble_sync_cc</key>
<param><key>id</key><value>gfdm_simple_preamble_sync_cc_0</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>frame_len</key><value>800</value></param>
<param><key>in_key</key><value>energy_start</value></param>
<param><key>out_key</key><value>frame_start</value></param>
<param><key>preamble</key><value>modulated_preambles[1]</value></param>
<param><key>subcarriers</key><value>64</value></param>
</block>
<block>
<key>hier_energy_burst_detector</key>
<param><key>id</key><value>hier_energy_burst_detector_0</value></param>
<param><key>burst_backoff</key><value>burst_backoff</value></param>
<param><key>burst_tag_key</key><value>'energy_start'</value></param>
<param><key>peak_look_ahead_value</key><value>look_ahead_val</value></param>
<param><key>peak_th_factor</key><value>10.</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import scipy.signal as signal</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_filters</value></param>
<param><key>import</key><value>from gfdm.pygfdm import filters</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_mapping</value></param>
<param><key>import</key><value>from gfdm.pygfdm import mapping</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_synchronization</value></param>
<param><key>import</key><value>from gfdm.pygfdm import utils</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_synchronization_0</value></param>
<param><key>import</key><value>from gfdm.pygfdm import preamble as pre_module</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>0,0,3,3</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>sync_tab@0: 0, 0, 1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Energy-detected bursts"</value></param>
<param><key>size</key><value>800 * 12</value></param>
<param><key>srate</key><value>samp_rate * 0 + 1</value></param>
<param><key>tr_level</key><value>0.05</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"energy_start"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>sync_tab@0: 1, 0, 1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Frame-synchronized bursts"</value></param>
<param><key>size</key><value>800 * 4</value></param>
<param><key>srate</key><value>samp_rate * 0 + 1</value></param>
<param><key>tr_level</key><value>0.05</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>"frame_start"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_1</value></param>
<param><key>gui_hint</key><value>sync_tab@0: 2, 0, 1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>name</key><value>"Channel Estimate"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>576</value></param>
<param><key>srate</key><value>samp_rate * 0 + 1</value></param>
<param><key>tr_level</key><value>0.05</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>tr_tag</key><value>"frame_start"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.005</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>sync_sink</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>sync_tab</value></param>
<param><key>gui_hint</key><value>3,0,4,4</value></param>
<param><key>label0</key><value>Synchronization</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>hier_energy_burst_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_advanced_receiver_sb_cc_0</source_block_id><sink_block_id>gfdm_resource_demapper_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_channel_estimator_cc_0</source_block_id><sink_block_id>gfdm_advanced_receiver_sb_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gfdm_channel_estimator_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gfdm_extract_burst_cc_0</source_block_id><sink_block_id>gfdm_simple_preamble_sync_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_extract_burst_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_remove_prefix_cc_0</source_block_id><sink_block_id>gfdm_channel_estimator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_remove_prefix_cc_0_0</source_block_id><sink_block_id>gfdm_advanced_receiver_sb_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_remove_prefix_cc_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_resource_demapper_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>cfo</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>gfdm_remove_prefix_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>gfdm_remove_prefix_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_preamble_sync_cc_0</source_block_id><sink_block_id>sync_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hier_energy_burst_detector_0</source_block_id><sink_block_id>gfdm_extract_burst_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
