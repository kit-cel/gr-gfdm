options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: simple_modulator
    output_language: python
  states: {}

blocks:
- name: active_subcarriers
  id: variable
  parameters:
    value: subcarriers - (subcarriers // 4)
  states: {}
- name: block_len
  id: variable
  parameters:
    value: timeslots * subcarriers
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: subcarriers // 2
  states: {}
- name: cs_len
  id: variable
  parameters:
    value: ramp_len
  states: {}
- name: filter_taps
  id: variable
  parameters:
    value: filters.get_frequency_domain_filter('rrc', 1.0, timeslots, subcarriers, overlap)
  states: {}
- name: frame_gap
  id: variable
  parameters:
    value: 128 * 8
  states: {}
- name: frame_len
  id: variable
  parameters:
    value: window_len + len(preamble)
  states: {}
- name: modulated_preambles
  id: variable
  parameters:
    value: pre_module.mapped_preamble(seed, 'rrc', .2, active_subcarriers, subcarriers, subcarrier_map, overlap, cp_len, ramp_len)
  states: {}
- name: overlap
  id: variable
  parameters:
    value: '2'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: modulated_preambles[0]
  states: {}
- name: ramp_len
  id: variable
  parameters:
    value: cp_len // 2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e7
  states: {}
- name: seed
  id: variable
  parameters:
    value: utils.generate_seed('awesome preamble')
  states: {}
- name: subcarrier_map
  id: variable
  parameters:
    value: mapping.get_subcarrier_map(subcarriers, active_subcarriers, dc_free=True)
  states: {}
- name: subcarriers
  id: variable
  parameters:
    value: '32'
  states: {}
- name: timeslots
  id: variable
  parameters:
    value: '75'
  states: {}
- name: window_len
  id: variable
  parameters:
    value: block_len + cp_len + cs_len
  states: {}
- name: window_taps
  id: variable
  parameters:
    value: cyclic_prefix.get_root_raised_cosine_ramp(ramp_len, window_len)
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '3'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '32'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate / 10
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: np.array([1+1j, -1+1j, -1-1j, 1-1j]) / np.sqrt(2.)
  states: {}
- name: gfdm_cyclic_prefixer_cc_0
  id: gfdm_cyclic_prefixer_cc
  parameters:
    block_len: block_len
    cp_length: cp_len
    cs_length: cs_len
    ramp_len: ramp_len
    window_taps: window_taps
  states: {}
- name: gfdm_resource_mapper_cc_0
  id: gfdm_resource_mapper_cc
  parameters:
    active_subcarriers: active_subcarriers
    per_timeslot: 'True'
    subcarrier_map: subcarrier_map
    subcarriers: subcarriers
    timeslots: timeslots
  states: {}
- name: gfdm_simple_modulator_cc_0
  id: gfdm_simple_modulator_cc
  parameters:
    frequency_taps: filter_taps
    n_subcarriers: subcarriers
    n_timeslots: timeslots
    overlap: overlap
  states: {}
- name: import_cp
  id: import
  parameters:
    imports: from gfdm.pygfdm import  cyclic_prefix
  states: {}
- name: import_mapping
  id: import
  parameters:
    imports: from gfdm.pygfdm import mapping
  states: {}
- name: import_np
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_pygfdm
  id: import
  parameters:
    imports: from gfdm.pygfdm import  filters
  states: {}
- name: import_sync
  id: import
  parameters:
    imports: from gfdm.pygfdm import  preamble as pre_module
  states: {}
- name: import_utils
  id: import
  parameters:
    imports: from gfdm.pygfdm import  utils
  states: {}
- name: preamble_vector_insert
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: frame_len
    type: complex
    vector: preamble
  states: {}
- name: preamble_vector_insert_0
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: frame_len + frame_gap
    type: complex
    vector: np.zeros(frame_gap)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    alpha3: '0.0'
    alpha4: '0.0'
    grid: 'True'
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    nconnections: '2'
    size: 4 * frame_len
    srate: samp_rate
    tr_chan: '2'
    tr_delay: 64. / samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"gfdm_frame"'
    type: complex
    ymax: '1.'
    ymin: '-1.'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '-10.'
    int_min: '-80.'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_random_source_x_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_moving_average_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', gfdm_resource_mapper_cc_0, '0']
- [gfdm_cyclic_prefixer_cc_0, '0', preamble_vector_insert, '0']
- [gfdm_resource_mapper_cc_0, '0', gfdm_simple_modulator_cc_0, '0']
- [gfdm_simple_modulator_cc_0, '0', gfdm_cyclic_prefixer_cc_0, '0']
- [preamble_vector_insert, '0', preamble_vector_insert_0, '0']
- [preamble_vector_insert_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
