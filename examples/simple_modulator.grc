<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_taps</value></param>
<param><key>value</key><value>filters.get_frequency_domain_filter('rrc', 1.0, timeslots, subcarriers, overlap)</value></param>
</block>
<block>
<key>variable_preamble_generator</key>
<param><key>id</key><value>gfdm_pregen</value></param>
<param><key>filter_alpha</key><value>.5</value></param>
<param><key>nsubcarrier</key><value>subcarriers</value></param>
<param><key>sync_fft_len</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>overlap</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subcarriers</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>timeslots</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor</key>
<param><key>id</key><value>blocks_ctrlport_monitor_0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor_performance</key>
<param><key>id</key><value>blocks_ctrlport_monitor_performance_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>range(2, 4, timeslots * subcarriers)</value></param>
</block>
<block>
<key>gfdm_framer_cc</key>
<param><key>id</key><value>gfdm_framer_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>nsubcarrier</key><value>subcarriers</value></param>
<param><key>ntimeslots</key><value>timeslots</value></param>
<param><key>preamble_generator</key><value>gfdm_pregen</value></param>
<param><key>sync</key><value>False</value></param>
<param><key>sync_symbols</key><value></value></param>
</block>
<block>
<key>gfdm_modulator_cc</key>
<param><key>id</key><value>gfdm_modulator_cc_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_len</key><value>subcarriers * timeslots</value></param>
<param><key>filter_alpha</key><value>.5</value></param>
<param><key>len_tag_key</key><value>"gfdm_frame"</value></param>
<param><key>nsubcarrier</key><value>subcarriers</value></param>
<param><key>ntimeslots</key><value>timeslots</value></param>
<param><key>sync_fft_len</key><value>1</value></param>
</block>
<block>
<key>gfdm_simple_modulator_cc</key>
<param><key>id</key><value>gfdm_simple_modulator_cc_0</value></param>
<param><key>frequency_taps</key><value>f_taps</value></param>
<param><key>n_subcarriers</key><value>subcarriers</value></param>
<param><key>overlap</key><value>overlap</value></param>
<param><key>n_timeslots</key><value>timeslots</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_pygfdm</value></param>
<param><key>import</key><value>from gfdm.pygfdm import  filters</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>gfdm_simple_modulator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>gfdm_framer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>gfdm_simple_modulator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_framer_cc_0</source_block_id><sink_block_id>gfdm_modulator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_modulator_cc_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_modulator_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
