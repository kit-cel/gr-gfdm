<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>demo_no_sync</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>GFDM Demo without sync</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_taps</value></param>
<param><key>value</key><value>filters.get_frequency_domain_filter('rrc', .5, gfdm_var.timeslots, gfdm_var.subcarriers, gfdm_var.overlap)</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>gfdm_constellation</value></param>
<param><key>const_points</key><value>[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>gfdm_var</value></param>
<param><key>field0</key><value>subcarriers</value></param>
<param><key>field1</key><value>timeslots</value></param>
<param><key>field2</key><value>alpha</value></param>
<param><key>field3</key><value>overlap</value></param>
<param><key>value2</key><value>.5</value></param>
<param><key>value3</key><value>2</value></param>
<param><key>value0</key><value>64</value></param>
<param><key>value1</key><value>9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ic_iter_range</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Interference Cancellation Iteration Count</value></param>
<param><key>min_len</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>256</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_f_taps</value></param>
<param><key>value</key><value>numpy.conjugate(f_taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>len(gfdm_constellation.points())</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>100*gfdm_var.timeslots*gfdm_var.subcarriers</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>1./gfdm_var.subcarriers</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"frame_len"</value></param>
<param><key>packet_len</key><value>gfdm_var.timeslots*gfdm_var.subcarriers</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>1e6</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>gfdm_constellation.points()</value></param>
</block>
<block>
<key>gfdm_advanced_receiver_sb_cc</key>
<param><key>id</key><value>gfdm_advanced_receiver_sb_cc_0</value></param>
<param><key>constellation</key><value>gfdm_constellation</value></param>
<param><key>frequency_taps</key><value>rx_f_taps</value></param>
<param><key>ic_iter</key><value>ic_iter_range</value></param>
<param><key>overlap</key><value>gfdm_var.overlap</value></param>
<param><key>timeslots</key><value>gfdm_var.timeslots</value></param>
<param><key>subcarriers</key><value>gfdm_var.subcarriers</value></param>
<param><key>subcarrier_map</key><value>numpy.arange(gfdm_var.subcarriers)</value></param>
</block>
<block>
<key>gfdm_advanced_receiver_tsb_cc</key>
<param><key>id</key><value>gfdm_advanced_receiver_tsb_cc_0</value></param>
<param><key>constellation</key><value>gfdm_constellation</value></param>
<param><key>frequency_taps</key><value>rx_f_taps</value></param>
<param><key>ic_iter</key><value>ic_iter_range</value></param>
<param><key>overlap</key><value>gfdm_var.overlap</value></param>
<param><key>len_tag_key</key><value> "frame_len"</value></param>
<param><key>timeslots</key><value>gfdm_var.timeslots</value></param>
<param><key>subcarriers</key><value>gfdm_var.subcarriers</value></param>
</block>
<block>
<key>gfdm_simple_modulator_cc</key>
<param><key>id</key><value>gfdm_simple_modulator_cc_0</value></param>
<param><key>frequency_taps</key><value>f_taps</value></param>
<param><key>n_subcarriers</key><value>gfdm_var.subcarriers</value></param>
<param><key>overlap</key><value>gfdm_var.overlap</value></param>
<param><key>n_timeslots</key><value>gfdm_var.timeslots</value></param>
</block>
<block>
<key>gfdm_simple_receiver_cc</key>
<param><key>id</key><value>gfdm_simple_receiver_cc_0</value></param>
<param><key>frequency_taps</key><value>rx_f_taps</value></param>
<param><key>n_subcarriers</key><value>gfdm_var.subcarriers</value></param>
<param><key>overlap</key><value>gfdm_var.overlap</value></param>
<param><key>n_timeslots</key><value>gfdm_var.timeslots</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gfdm.pygfdm import filters</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@0:1,0,1,1</value></param>
<param><key>label1</key><value>transmitted symbols</value></param>
<param><key>label2</key><value>received symbols (simple demod)</value></param>
<param><key>label3</key><value>received symbols (adv. demod)</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>2*gfdm_var.subcarriers*gfdm_var.timeslots</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>qtgui_tab_widget_0</value></param>
<param><key>label0</key><value>Constellation</value></param>
<param><key>label1</key><value>Time</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@1:1,1,2,3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Re{d} transmitted symbols</value></param>
<param><key>color2</key><value>"Dark Blue"</value></param>
<param><key>label2</key><value>Im{d} transmitted symbols</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Re{d} received symbols (simple demod)</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>Im{d} received symbols (simple demod)</value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value>Re{d} received symbols (adv. receiver SB)</value></param>
<param><key>color6</key><value>"magenta"</value></param>
<param><key>label6</key><value>Im{d} received symbols (adv. receiver SB)</value></param>
<param><key>color7</key><value>"yellow"</value></param>
<param><key>label7</key><value>Re{d} received symbols (adv. receiver TSB)</value></param>
<param><key>color8</key><value>"dark red"</value></param>
<param><key>label8</key><value>Im{d} received symbols (adv. receiver TSB)</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>100</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>symbols_in</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>symbols_tx</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>symbols_out</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>symbols_out_ic</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_4</value></param>
<param><key>stream_id</key><value>symbols_out_ic_tsb</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>symbols_in</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>symbols_in</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>symbols_tx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>symbols_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>symbols_out_ic</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>stream_id</key><value>symbols_out_ic_tsb</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>gfdm_advanced_receiver_tsb_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_advanced_receiver_sb_cc_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_advanced_receiver_tsb_cc_0</source_block_id><sink_block_id>virtual_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_modulator_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gfdm_simple_receiver_cc_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>gfdm_simple_modulator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>gfdm_advanced_receiver_sb_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>gfdm_simple_receiver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
</flow_graph>
